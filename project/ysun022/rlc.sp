* 100 * 10, 1 RLC sections per segment
* rows = 100
* cols = 10
* sections = 1

** row: 0
C0_0 N0_0 0 1.83e-12
R0_1h N0_0 N1_0 0.067584
R0_1v N0_0 N100_0 0.061248
C1_0 N1_0 0 1.15e-12
R1_1h N1_0 N2_0 0.072512
R1_1v N1_0 N101_0 0.03168
C2_0 N2_0 0 1.86e-12
R2_1h N2_0 N3_0 0.071808
R2_1v N2_0 N102_0 0.041536
C3_0 N3_0 0 1.21e-12
R3_1h N3_0 N4_0 0.050688
R3_1v N3_0 N103_0 0.026048
C4_0 N4_0 0 1.9e-12
R4_1h N4_0 N5_0 0.048576
R4_1v N4_0 N104_0 0.051392
C5_0 N5_0 0 1.26e-12
R5_1h N5_0 N6_0 0.0352
R5_1v N5_0 N105_0 0.025344
C6_0 N6_0 0 1.72e-12
R6_1h N6_0 N7_0 0.032384
R6_1v N6_0 N106_0 0.014784
C7_0 N7_0 0 1.68e-12
R7_1h N7_0 N8_0 0.054208
R7_1v N7_0 N107_0 0.027456
C8_0 N8_0 0 1.82e-12
R8_1h N8_0 N9_0 0.02816
R8_1v N8_0 N108_0 0.050688
C9_0 N9_0 0 1.23e-12
R9_1v N9_0 N109_0 0.054208
** row: 1
C10_0 N10_0 0 1.35e-12
R10_1h N10_0 N11_0 0.027456
R10_1v N10_0 N110_0 0.008448
C11_0 N11_0 0 1.22e-12
R11_1h N11_0 N12_0 0.047872
R11_1v N11_0 N111_0 0.055616
C12_0 N12_0 0 1.67e-12
R12_1h N12_0 N13_0 0.072512
R12_1v N12_0 N112_0 0.046464
C13_0 N13_0 0 1.11e-12
R13_1h N13_0 N14_0 0.036608
R13_1v N13_0 N113_0 0.027456
C14_0 N14_0 0 1.73e-12
R14_1h N14_0 N15_0 0.021824
R14_1v N14_0 N114_0 0.020416
C15_0 N15_0 0 1.84e-12
R15_1h N15_0 N16_0 0.033088
R15_1v N15_0 N115_0 0.076032
C16_0 N16_0 0 1.24e-12
R16_1h N16_0 N17_0 0.0176
R16_1v N16_0 N116_0 0.05632
C17_0 N17_0 0 1.13e-12
R17_1h N17_0 N18_0 0.025344
R17_1v N17_0 N117_0 0.071104
C18_0 N18_0 0 1.8e-12
R18_1h N18_0 N19_0 0.046464
R18_1v N18_0 N118_0 0.058432
C19_0 N19_0 0 1.62e-12
R19_1v N19_0 N119_0 0.05632
** row: 2
C20_0 N20_0 0 1.96e-12
R20_1h N20_0 N21_0 0.064064
R20_1v N20_0 N120_0 0.01056
C21_0 N21_0 0 1.25e-12
R21_1h N21_0 N22_0 0.066176
R21_1v N21_0 N121_0 0.026048
C22_0 N22_0 0 1.36e-12
R22_1h N22_0 N23_0 0.01056
R22_1v N22_0 N122_0 0.039424
C23_0 N23_0 0 1.29e-12
R23_1h N23_0 N24_0 0.016192
R23_1v N23_0 N123_0 0.047168
C24_0 N24_0 0 1.24e-12
R24_1h N24_0 N25_0 0.07392
R24_1v N24_0 N124_0 0.064768
C25_0 N25_0 0 1.45e-12
R25_1h N25_0 N26_0 0.016896
R25_1v N25_0 N125_0 0.054208
C26_0 N26_0 0 1.34e-12
R26_1h N26_0 N27_0 0.052096
R26_1v N26_0 N126_0 0.037312
C27_0 N27_0 0 1.5e-12
R27_1h N27_0 N28_0 0.068288
R27_1v N27_0 N127_0 0.012672
C28_0 N28_0 0 1.76e-12
R28_1h N28_0 N29_0 0.061952
R28_1v N28_0 N128_0 0.068992
C29_0 N29_0 0 1.84e-12
R29_1v N29_0 N129_0 0.009152
** row: 3
C30_0 N30_0 0 1.51e-12
R30_1h N30_0 N31_0 0.045056
R30_1v N30_0 N130_0 0.076736
C31_0 N31_0 0 1.32e-12
R31_1h N31_0 N32_0 0.04928
R31_1v N31_0 N131_0 0.060544
C32_0 N32_0 0 1.68e-12
R32_1h N32_0 N33_0 0.034496
R32_1v N32_0 N132_0 0.015488
C33_0 N33_0 0 1.26e-12
R33_1h N33_0 N34_0 0.067584
R33_1v N33_0 N133_0 0.073216
C34_0 N34_0 0 1.39e-12
R34_1h N34_0 N35_0 0.07392
R34_1v N34_0 N134_0 0.05632
C35_0 N35_0 0 1.34e-12
R35_1h N35_0 N36_0 0.061952
R35_1v N35_0 N135_0 0.054208
C36_0 N36_0 0 1.01e-12
R36_1h N36_0 N37_0 0.075328
R36_1v N36_0 N136_0 0.008448
C37_0 N37_0 0 1.17e-12
R37_1h N37_0 N38_0 0.071808
R37_1v N37_0 N137_0 0.043648
C38_0 N38_0 0 1.56e-12
R38_1h N38_0 N39_0 0.007744
R38_1v N38_0 N138_0 0.06336
C39_0 N39_0 0 1.86e-12
R39_1v N39_0 N139_0 0.035904
** row: 4
C40_0 N40_0 0 1.65e-12
R40_1h N40_0 N41_0 0.069696
R40_1v N40_0 N140_0 0.038016
C41_0 N41_0 0 1.19e-12
R41_1h N41_0 N42_0 0.0352
R41_1v N41_0 N141_0 0.027456
C42_0 N42_0 0 1.31e-12
R42_1h N42_0 N43_0 0.019008
R42_1v N42_0 N142_0 0.075328
C43_0 N43_0 0 1.71e-12
R43_1h N43_0 N44_0 0.064064
R43_1v N43_0 N143_0 0.05984
C44_0 N44_0 0 1.09e-12
R44_1h N44_0 N45_0 0.026048
R44_1v N44_0 N144_0 0.054208
C45_0 N45_0 0 1.56e-12
R45_1h N45_0 N46_0 0.075328
R45_1v N45_0 N145_0 0.044352
C46_0 N46_0 0 1.86e-12
R46_1h N46_0 N47_0 0.0528
R46_1v N46_0 N146_0 0.011264
C47_0 N47_0 0 1.83e-12
R47_1h N47_0 N48_0 0.020416
R47_1v N47_0 N147_0 0.023936
C48_0 N48_0 0 1.28e-12
R48_1h N48_0 N49_0 0.057024
R48_1v N48_0 N148_0 0.029568
C49_0 N49_0 0 1.29e-12
R49_1v N49_0 N149_0 0.009152
** row: 5
C50_0 N50_0 0 1.19e-12
R50_1h N50_0 N51_0 0.05632
R50_1v N50_0 N150_0 0.054912
C51_0 N51_0 0 1.08e-12
R51_1h N51_0 N52_0 0.0176
R51_1v N51_0 N151_0 0.0352
C52_0 N52_0 0 1.49e-12
R52_1h N52_0 N53_0 0.074624
R52_1v N52_0 N152_0 0.023232
C53_0 N53_0 0 1.18e-12
R53_1h N53_0 N54_0 0.03872
R53_1v N53_0 N153_0 0.039424
C54_0 N54_0 0 1.51e-12
R54_1h N54_0 N55_0 0.021824
R54_1v N54_0 N154_0 0.04576
C55_0 N55_0 0 1.79e-12
R55_1h N55_0 N56_0 0.068992
R55_1v N55_0 N155_0 0.052096
C56_0 N56_0 0 1.28e-12
R56_1h N56_0 N57_0 0.035904
R56_1v N56_0 N156_0 0.04224
C57_0 N57_0 0 1.93e-12
R57_1h N57_0 N58_0 0.00704
R57_1v N57_0 N157_0 0.030976
C58_0 N58_0 0 1.64e-12
R58_1h N58_0 N59_0 0.023936
R58_1v N58_0 N158_0 0.016896
C59_0 N59_0 0 1.87e-12
R59_1v N59_0 N159_0 0.046464
** row: 6
C60_0 N60_0 0 1.43e-12
R60_1h N60_0 N61_0 0.071104
R60_1v N60_0 N160_0 0.026048
C61_0 N61_0 0 1.65e-12
R61_1h N61_0 N62_0 0.048576
R61_1v N61_0 N161_0 0.032384
C62_0 N62_0 0 1.32e-12
R62_1h N62_0 N63_0 0.042944
R62_1v N62_0 N162_0 0.033088
C63_0 N63_0 0 1.28e-12
R63_1h N63_0 N64_0 0.05984
R63_1v N63_0 N163_0 0.011968
C64_0 N64_0 0 1.74e-12
R64_1h N64_0 N65_0 0.021824
R64_1v N64_0 N164_0 0.047872
C65_0 N65_0 0 1.95e-12
R65_1h N65_0 N66_0 0.027456
R65_1v N65_0 N165_0 0.033088
C66_0 N66_0 0 1.35e-12
R66_1h N66_0 N67_0 0.072512
R66_1v N66_0 N166_0 0.019712
C67_0 N67_0 0 1.28e-12
R67_1h N67_0 N68_0 0.037312
R67_1v N67_0 N167_0 0.014784
C68_0 N68_0 0 1.28e-12
R68_1h N68_0 N69_0 0.027456
R68_1v N68_0 N168_0 0.060544
C69_0 N69_0 0 1.04e-12
R69_1v N69_0 N169_0 0.037312
** row: 7
C70_0 N70_0 0 1.63e-12
R70_1h N70_0 N71_0 0.016192
R70_1v N70_0 N170_0 0.033792
C71_0 N71_0 0 1.06e-12
R71_1h N71_0 N72_0 0.0352
R71_1v N71_0 N171_0 0.009856
C72_0 N72_0 0 1.18e-12
R72_1h N72_0 N73_0 0.026752
R72_1v N72_0 N172_0 0.068992
C73_0 N73_0 0 1.69e-12
R73_1h N73_0 N74_0 0.019008
R73_1v N73_0 N173_0 0.019008
C74_0 N74_0 0 1.96e-12
R74_1h N74_0 N75_0 0.023936
R74_1v N74_0 N174_0 0.037312
C75_0 N75_0 0 1.7e-12
R75_1h N75_0 N76_0 0.065472
R75_1v N75_0 N175_0 0.0704
C76_0 N76_0 0 1.99e-12
R76_1h N76_0 N77_0 0.057728
R76_1v N76_0 N176_0 0.02464
C77_0 N77_0 0 1.44e-12
R77_1h N77_0 N78_0 0.0704
R77_1v N77_0 N177_0 0.01056
C78_0 N78_0 0 1.39e-12
R78_1h N78_0 N79_0 0.045056
R78_1v N78_0 N178_0 0.067584
C79_0 N79_0 0 1.69e-12
R79_1v N79_0 N179_0 0.064768
** row: 8
C80_0 N80_0 0 1.42e-12
R80_1h N80_0 N81_0 0.052096
R80_1v N80_0 N180_0 0.075328
C81_0 N81_0 0 1.07e-12
R81_1h N81_0 N82_0 0.04576
R81_1v N81_0 N181_0 0.009856
C82_0 N82_0 0 1.48e-12
R82_1h N82_0 N83_0 0.014784
R82_1v N82_0 N182_0 0.022528
C83_0 N83_0 0 1.28e-12
R83_1h N83_0 N84_0 0.076736
R83_1v N83_0 N183_0 0.037312
C84_0 N84_0 0 1.46e-12
R84_1h N84_0 N85_0 0.054912
R84_1v N84_0 N184_0 0.0352
C85_0 N85_0 0 1.22e-12
R85_1h N85_0 N86_0 0.014784
R85_1v N85_0 N185_0 0.01408
C86_0 N86_0 0 1.05e-12
R86_1h N86_0 N87_0 0.007744
R86_1v N86_0 N186_0 0.049984
C87_0 N87_0 0 1.3e-12
R87_1h N87_0 N88_0 0.061952
R87_1v N87_0 N187_0 0.01056
C88_0 N88_0 0 1.2e-12
R88_1h N88_0 N89_0 0.032384
R88_1v N88_0 N188_0 0.038016
C89_0 N89_0 0 1.26e-12
R89_1v N89_0 N189_0 0.022528
** row: 9
C90_0 N90_0 0 1.65e-12
R90_1h N90_0 N91_0 0.012672
R90_1v N90_0 N190_0 0.018304
C91_0 N91_0 0 1.82e-12
R91_1h N91_0 N92_0 0.047872
R91_1v N91_0 N191_0 0.023936
C92_0 N92_0 0 1.37e-12
R92_1h N92_0 N93_0 0.050688
R92_1v N92_0 N192_0 0.023936
C93_0 N93_0 0 1e-12
R93_1h N93_0 N94_0 0.032384
R93_1v N93_0 N193_0 0.043648
C94_0 N94_0 0 1.99e-12
R94_1h N94_0 N95_0 0.062656
R94_1v N94_0 N194_0 0.04224
C95_0 N95_0 0 1.68e-12
R95_1h N95_0 N96_0 0.057024
R95_1v N95_0 N195_0 0.058432
C96_0 N96_0 0 1.31e-12
R96_1h N96_0 N97_0 0.064064
R96_1v N96_0 N196_0 0.02816
C97_0 N97_0 0 1.33e-12
R97_1h N97_0 N98_0 0.073216
R97_1v N97_0 N197_0 0.04928
C98_0 N98_0 0 1.63e-12
R98_1h N98_0 N99_0 0.076736
R98_1v N98_0 N198_0 0.064064
C99_0 N99_0 0 1.99e-12
R99_1v N99_0 N199_0 0.074624
** row: 10
C100_0 N100_0 0 1.59e-12
R100_1h N100_0 N101_0 0.058432
R100_1v N100_0 N200_0 0.016192
C101_0 N101_0 0 1.68e-12
R101_1h N101_0 N102_0 0.0704
R101_1v N101_0 N201_0 0.07392
C102_0 N102_0 0 1.26e-12
R102_1h N102_0 N103_0 0.053504
R102_1v N102_0 N202_0 0.066176
C103_0 N103_0 0 1.4e-12
R103_1h N103_0 N104_0 0.0704
R103_1v N103_0 N203_0 0.066176
C104_0 N104_0 0 1.76e-12
R104_1h N104_0 N105_0 0.036608
R104_1v N104_0 N204_0 0.032384
C105_0 N105_0 0 1.07e-12
R105_1h N105_0 N106_0 0.03872
R105_1v N105_0 N205_0 0.046464
C106_0 N106_0 0 1.79e-12
R106_1h N106_0 N107_0 0.019712
R106_1v N106_0 N206_0 0.068288
C107_0 N107_0 0 1.12e-12
R107_1h N107_0 N108_0 0.040832
R107_1v N107_0 N207_0 0.057728
C108_0 N108_0 0 1.59e-12
R108_1h N108_0 N109_0 0.013376
R108_1v N108_0 N208_0 0.032384
C109_0 N109_0 0 1.1e-12
R109_1v N109_0 N209_0 0.036608
** row: 11
C110_0 N110_0 0 1.87e-12
R110_1h N110_0 N111_0 0.011264
R110_1v N110_0 N210_0 0.007744
C111_0 N111_0 0 1.13e-12
R111_1h N111_0 N112_0 0.057728
R111_1v N111_0 N211_0 0.021824
C112_0 N112_0 0 1.55e-12
R112_1h N112_0 N113_0 0.020416
R112_1v N112_0 N212_0 0.076736
C113_0 N113_0 0 1.21e-12
R113_1h N113_0 N114_0 0.009856
R113_1v N113_0 N213_0 0.034496
C114_0 N114_0 0 1.11e-12
R114_1h N114_0 N115_0 0.0352
R114_1v N114_0 N214_0 0.054208
C115_0 N115_0 0 1.05e-12
R115_1h N115_0 N116_0 0.026752
R115_1v N115_0 N215_0 0.026048
C116_0 N116_0 0 1.5e-12
R116_1h N116_0 N117_0 0.066176
R116_1v N116_0 N216_0 0.047872
C117_0 N117_0 0 1.2e-12
R117_1h N117_0 N118_0 0.023936
R117_1v N117_0 N217_0 0.022528
C118_0 N118_0 0 1.69e-12
R118_1h N118_0 N119_0 0.074624
R118_1v N118_0 N218_0 0.064064
C119_0 N119_0 0 1.3e-12
R119_1v N119_0 N219_0 0.066176
** row: 12
C120_0 N120_0 0 1.92e-12
R120_1h N120_0 N121_0 0.057728
R120_1v N120_0 N220_0 0.057728
C121_0 N121_0 0 1.5e-12
R121_1h N121_0 N122_0 0.02464
R121_1v N121_0 N221_0 0.06688
C122_0 N122_0 0 1.22e-12
R122_1h N122_0 N123_0 0.076736
R122_1v N122_0 N222_0 0.0352
C123_0 N123_0 0 1.42e-12
R123_1h N123_0 N124_0 0.076032
R123_1v N123_0 N223_0 0.016192
C124_0 N124_0 0 1.98e-12
R124_1h N124_0 N125_0 0.0704
R124_1v N124_0 N224_0 0.023936
C125_0 N125_0 0 1.9e-12
R125_1h N125_0 N126_0 0.013376
R125_1v N125_0 N225_0 0.064064
C126_0 N126_0 0 1.19e-12
R126_1h N126_0 N127_0 0.032384
R126_1v N126_0 N226_0 0.029568
C127_0 N127_0 0 1.55e-12
R127_1h N127_0 N128_0 0.073216
R127_1v N127_0 N227_0 0.009856
C128_0 N128_0 0 1.79e-12
R128_1h N128_0 N129_0 0.055616
R128_1v N128_0 N228_0 0.058432
C129_0 N129_0 0 1.76e-12
R129_1v N129_0 N229_0 0.04224
** row: 13
C130_0 N130_0 0 1.55e-12
R130_1h N130_0 N131_0 0.04928
R130_1v N130_0 N230_0 0.036608
C131_0 N131_0 0 1.79e-12
R131_1h N131_0 N132_0 0.066176
R131_1v N131_0 N231_0 0.072512
C132_0 N132_0 0 1.05e-12
R132_1h N132_0 N133_0 0.021824
R132_1v N132_0 N232_0 0.054208
C133_0 N133_0 0 1.04e-12
R133_1h N133_0 N134_0 0.016192
R133_1v N133_0 N233_0 0.049984
C134_0 N134_0 0 1.54e-12
R134_1h N134_0 N135_0 0.025344
R134_1v N134_0 N234_0 0.048576
C135_0 N135_0 0 1.44e-12
R135_1h N135_0 N136_0 0.008448
R135_1v N135_0 N235_0 0.008448
C136_0 N136_0 0 1.06e-12
R136_1h N136_0 N137_0 0.066176
R136_1v N136_0 N236_0 0.021824
C137_0 N137_0 0 1.42e-12
R137_1h N137_0 N138_0 0.054912
R137_1v N137_0 N237_0 0.026752
C138_0 N138_0 0 1.89e-12
R138_1h N138_0 N139_0 0.057728
R138_1v N138_0 N238_0 0.012672
C139_0 N139_0 0 1.58e-12
R139_1v N139_0 N239_0 0.076032
** row: 14
C140_0 N140_0 0 1.36e-12
R140_1h N140_0 N141_0 0.012672
R140_1v N140_0 N240_0 0.044352
C141_0 N141_0 0 1.48e-12
R141_1h N141_0 N142_0 0.009152
R141_1v N141_0 N241_0 0.030272
C142_0 N142_0 0 1.33e-12
R142_1h N142_0 N143_0 0.040832
R142_1v N142_0 N242_0 0.0704
C143_0 N143_0 0 1.54e-12
R143_1h N143_0 N144_0 0.054208
R143_1v N143_0 N243_0 0.039424
C144_0 N144_0 0 1.68e-12
R144_1h N144_0 N145_0 0.027456
R144_1v N144_0 N244_0 0.00704
C145_0 N145_0 0 1.46e-12
R145_1h N145_0 N146_0 0.068992
R145_1v N145_0 N245_0 0.075328
C146_0 N146_0 0 1.49e-12
R146_1h N146_0 N147_0 0.0704
R146_1v N146_0 N246_0 0.009152
C147_0 N147_0 0 1.33e-12
R147_1h N147_0 N148_0 0.051392
R147_1v N147_0 N247_0 0.075328
C148_0 N148_0 0 1.53e-12
R148_1h N148_0 N149_0 0.071808
R148_1v N148_0 N248_0 0.067584
C149_0 N149_0 0 1.25e-12
R149_1v N149_0 N249_0 0.043648
** row: 15
C150_0 N150_0 0 1.96e-12
R150_1h N150_0 N151_0 0.05984
R150_1v N150_0 N250_0 0.068992
C151_0 N151_0 0 1.57e-12
R151_1h N151_0 N152_0 0.027456
R151_1v N151_0 N251_0 0.032384
C152_0 N152_0 0 1.6e-12
R152_1h N152_0 N153_0 0.016896
R152_1v N152_0 N252_0 0.021824
C153_0 N153_0 0 1.6e-12
R153_1h N153_0 N154_0 0.009856
R153_1v N153_0 N253_0 0.026752
C154_0 N154_0 0 1.27e-12
R154_1h N154_0 N155_0 0.04224
R154_1v N154_0 N254_0 0.040832
C155_0 N155_0 0 1.56e-12
R155_1h N155_0 N156_0 0.008448
R155_1v N155_0 N255_0 0.073216
C156_0 N156_0 0 1.97e-12
R156_1h N156_0 N157_0 0.076736
R156_1v N156_0 N256_0 0.037312
C157_0 N157_0 0 1.39e-12
R157_1h N157_0 N158_0 0.008448
R157_1v N157_0 N257_0 0.026752
C158_0 N158_0 0 1.03e-12
R158_1h N158_0 N159_0 0.00704
R158_1v N158_0 N258_0 0.064064
C159_0 N159_0 0 1.47e-12
R159_1v N159_0 N259_0 0.033792
** row: 16
C160_0 N160_0 0 1.59e-12
R160_1h N160_0 N161_0 0.042944
R160_1v N160_0 N260_0 0.03168
C161_0 N161_0 0 1.34e-12
R161_1h N161_0 N162_0 0.034496
R161_1v N161_0 N261_0 0.071808
C162_0 N162_0 0 1.15e-12
R162_1h N162_0 N163_0 0.026048
R162_1v N162_0 N262_0 0.009856
C163_0 N163_0 0 1.29e-12
R163_1h N163_0 N164_0 0.041536
R163_1v N163_0 N263_0 0.052096
C164_0 N164_0 0 1.85e-12
R164_1h N164_0 N165_0 0.027456
R164_1v N164_0 N264_0 0.037312
C165_0 N165_0 0 1.35e-12
R165_1h N165_0 N166_0 0.061248
R165_1v N165_0 N265_0 0.00704
C166_0 N166_0 0 1.38e-12
R166_1h N166_0 N167_0 0.057024
R166_1v N166_0 N266_0 0.041536
C167_0 N167_0 0 1.89e-12
R167_1h N167_0 N168_0 0.054208
R167_1v N167_0 N267_0 0.068992
C168_0 N168_0 0 1.92e-12
R168_1h N168_0 N169_0 0.07392
R168_1v N168_0 N268_0 0.037312
C169_0 N169_0 0 1.44e-12
R169_1v N169_0 N269_0 0.027456
** row: 17
C170_0 N170_0 0 1.9e-12
R170_1h N170_0 N171_0 0.064768
R170_1v N170_0 N270_0 0.0352
C171_0 N171_0 0 1.41e-12
R171_1h N171_0 N172_0 0.055616
R171_1v N171_0 N271_0 0.025344
C172_0 N172_0 0 1.32e-12
R172_1h N172_0 N173_0 0.049984
R172_1v N172_0 N272_0 0.036608
C173_0 N173_0 0 1.6e-12
R173_1h N173_0 N174_0 0.019008
R173_1v N173_0 N273_0 0.023232
C174_0 N174_0 0 1.61e-12
R174_1h N174_0 N175_0 0.064064
R174_1v N174_0 N274_0 0.013376
C175_0 N175_0 0 1.9e-12
R175_1h N175_0 N176_0 0.02464
R175_1v N175_0 N275_0 0.074624
C176_0 N176_0 0 1.67e-12
R176_1h N176_0 N177_0 0.061248
R176_1v N176_0 N276_0 0.030976
C177_0 N177_0 0 1.9e-12
R177_1h N177_0 N178_0 0.025344
R177_1v N177_0 N277_0 0.023936
C178_0 N178_0 0 1.57e-12
R178_1h N178_0 N179_0 0.016896
R178_1v N178_0 N278_0 0.054912
C179_0 N179_0 0 1.05e-12
R179_1v N179_0 N279_0 0.047872
** row: 18
C180_0 N180_0 0 1.12e-12
R180_1h N180_0 N181_0 0.067584
R180_1v N180_0 N280_0 0.00704
C181_0 N181_0 0 1.46e-12
R181_1h N181_0 N182_0 0.025344
R181_1v N181_0 N281_0 0.073216
C182_0 N182_0 0 1.16e-12
R182_1h N182_0 N183_0 0.043648
R182_1v N182_0 N282_0 0.061952
C183_0 N183_0 0 1.29e-12
R183_1h N183_0 N184_0 0.039424
R183_1v N183_0 N283_0 0.0704
C184_0 N184_0 0 1.47e-12
R184_1h N184_0 N185_0 0.05632
R184_1v N184_0 N284_0 0.042944
C185_0 N185_0 0 1.8e-12
R185_1h N185_0 N186_0 0.028864
R185_1v N185_0 N285_0 0.072512
C186_0 N186_0 0 1.57e-12
R186_1h N186_0 N187_0 0.026048
R186_1v N186_0 N286_0 0.015488
C187_0 N187_0 0 1.86e-12
R187_1h N187_0 N188_0 0.016896
R187_1v N187_0 N287_0 0.04576
C188_0 N188_0 0 1.12e-12
R188_1h N188_0 N189_0 0.0704
R188_1v N188_0 N288_0 0.015488
C189_0 N189_0 0 1.79e-12
R189_1v N189_0 N289_0 0.01408
** row: 19
C190_0 N190_0 0 1.69e-12
R190_1h N190_0 N191_0 0.069696
R190_1v N190_0 N290_0 0.059136
C191_0 N191_0 0 1.55e-12
R191_1h N191_0 N192_0 0.035904
R191_1v N191_0 N291_0 0.02112
C192_0 N192_0 0 1.33e-12
R192_1h N192_0 N193_0 0.068288
R192_1v N192_0 N292_0 0.068992
C193_0 N193_0 0 1.38e-12
R193_1h N193_0 N194_0 0.053504
R193_1v N193_0 N293_0 0.05632
C194_0 N194_0 0 1.84e-12
R194_1h N194_0 N195_0 0.046464
R194_1v N194_0 N294_0 0.019008
C195_0 N195_0 0 1.06e-12
R195_1h N195_0 N196_0 0.04928
R195_1v N195_0 N295_0 0.041536
C196_0 N196_0 0 1.37e-12
R196_1h N196_0 N197_0 0.01056
R196_1v N196_0 N296_0 0.048576
C197_0 N197_0 0 1.17e-12
R197_1h N197_0 N198_0 0.019712
R197_1v N197_0 N297_0 0.03872
C198_0 N198_0 0 1.83e-12
R198_1h N198_0 N199_0 0.058432
R198_1v N198_0 N298_0 0.047872
C199_0 N199_0 0 1.73e-12
R199_1v N199_0 N299_0 0.033088
** row: 20
C200_0 N200_0 0 1.89e-12
R200_1h N200_0 N201_0 0.065472
R200_1v N200_0 N300_0 0.011968
C201_0 N201_0 0 1.78e-12
R201_1h N201_0 N202_0 0.047168
R201_1v N201_0 N301_0 0.016896
C202_0 N202_0 0 1.71e-12
R202_1h N202_0 N203_0 0.027456
R202_1v N202_0 N302_0 0.00704
C203_0 N203_0 0 1.59e-12
R203_1h N203_0 N204_0 0.019712
R203_1v N203_0 N303_0 0.033792
C204_0 N204_0 0 1.25e-12
R204_1h N204_0 N205_0 0.068992
R204_1v N204_0 N304_0 0.059136
C205_0 N205_0 0 1.33e-12
R205_1h N205_0 N206_0 0.047168
R205_1v N205_0 N305_0 0.064064
C206_0 N206_0 0 1.93e-12
R206_1h N206_0 N207_0 0.047872
R206_1v N206_0 N306_0 0.05632
C207_0 N207_0 0 1.99e-12
R207_1h N207_0 N208_0 0.019008
R207_1v N207_0 N307_0 0.034496
C208_0 N208_0 0 1.69e-12
R208_1h N208_0 N209_0 0.051392
R208_1v N208_0 N308_0 0.022528
C209_0 N209_0 0 1.94e-12
R209_1v N209_0 N309_0 0.058432
** row: 21
C210_0 N210_0 0 1.47e-12
R210_1h N210_0 N211_0 0.028864
R210_1v N210_0 N310_0 0.050688
C211_0 N211_0 0 1.82e-12
R211_1h N211_0 N212_0 0.0704
R211_1v N211_0 N311_0 0.071808
C212_0 N212_0 0 1.91e-12
R212_1h N212_0 N213_0 0.047168
R212_1v N212_0 N312_0 0.0176
C213_0 N213_0 0 1.21e-12
R213_1h N213_0 N214_0 0.047168
R213_1v N213_0 N313_0 0.059136
C214_0 N214_0 0 1.91e-12
R214_1h N214_0 N215_0 0.040128
R214_1v N214_0 N314_0 0.042944
C215_0 N215_0 0 1.31e-12
R215_1h N215_0 N216_0 0.021824
R215_1v N215_0 N315_0 0.033088
C216_0 N216_0 0 1.4e-12
R216_1h N216_0 N217_0 0.045056
R216_1v N216_0 N316_0 0.02816
C217_0 N217_0 0 1.98e-12
R217_1h N217_0 N218_0 0.02464
R217_1v N217_0 N317_0 0.064064
C218_0 N218_0 0 1.16e-12
R218_1h N218_0 N219_0 0.018304
R218_1v N218_0 N318_0 0.008448
C219_0 N219_0 0 1.31e-12
R219_1v N219_0 N319_0 0.034496
** row: 22
C220_0 N220_0 0 1.96e-12
R220_1h N220_0 N221_0 0.009856
R220_1v N220_0 N320_0 0.033792
C221_0 N221_0 0 1.8e-12
R221_1h N221_0 N222_0 0.019712
R221_1v N221_0 N321_0 0.021824
C222_0 N222_0 0 1.7e-12
R222_1h N222_0 N223_0 0.050688
R222_1v N222_0 N322_0 0.015488
C223_0 N223_0 0 1.79e-12
R223_1h N223_0 N224_0 0.061248
R223_1v N223_0 N323_0 0.06688
C224_0 N224_0 0 1.36e-12
R224_1h N224_0 N225_0 0.009856
R224_1v N224_0 N324_0 0.060544
C225_0 N225_0 0 1.83e-12
R225_1h N225_0 N226_0 0.011968
R225_1v N225_0 N325_0 0.048576
C226_0 N226_0 0 1.57e-12
R226_1h N226_0 N227_0 0.038016
R226_1v N226_0 N326_0 0.076736
C227_0 N227_0 0 1.11e-12
R227_1h N227_0 N228_0 0.026048
R227_1v N227_0 N327_0 0.04224
C228_0 N228_0 0 1.36e-12
R228_1h N228_0 N229_0 0.04928
R228_1v N228_0 N328_0 0.019712
C229_0 N229_0 0 1.05e-12
R229_1v N229_0 N329_0 0.051392
** row: 23
C230_0 N230_0 0 1.49e-12
R230_1h N230_0 N231_0 0.038016
R230_1v N230_0 N330_0 0.014784
C231_0 N231_0 0 1.05e-12
R231_1h N231_0 N232_0 0.030976
R231_1v N231_0 N331_0 0.071104
C232_0 N232_0 0 1.75e-12
R232_1h N232_0 N233_0 0.04576
R232_1v N232_0 N332_0 0.016896
C233_0 N233_0 0 1.89e-12
R233_1h N233_0 N234_0 0.054912
R233_1v N233_0 N333_0 0.072512
C234_0 N234_0 0 1.18e-12
R234_1h N234_0 N235_0 0.01056
R234_1v N234_0 N334_0 0.064768
C235_0 N235_0 0 1.22e-12
R235_1h N235_0 N236_0 0.064768
R235_1v N235_0 N335_0 0.019008
C236_0 N236_0 0 1.3e-12
R236_1h N236_0 N237_0 0.072512
R236_1v N236_0 N336_0 0.059136
C237_0 N237_0 0 1.26e-12
R237_1h N237_0 N238_0 0.072512
R237_1v N237_0 N337_0 0.067584
C238_0 N238_0 0 1.53e-12
R238_1h N238_0 N239_0 0.037312
R238_1v N238_0 N338_0 0.059136
C239_0 N239_0 0 1.14e-12
R239_1v N239_0 N339_0 0.016192
** row: 24
C240_0 N240_0 0 1.79e-12
R240_1h N240_0 N241_0 0.061248
R240_1v N240_0 N340_0 0.050688
C241_0 N241_0 0 1.75e-12
R241_1h N241_0 N242_0 0.068992
R241_1v N241_0 N341_0 0.020416
C242_0 N242_0 0 1.1e-12
R242_1h N242_0 N243_0 0.029568
R242_1v N242_0 N342_0 0.073216
C243_0 N243_0 0 1.17e-12
R243_1h N243_0 N244_0 0.039424
R243_1v N243_0 N343_0 0.03168
C244_0 N244_0 0 1.37e-12
R244_1h N244_0 N245_0 0.071104
R244_1v N244_0 N344_0 0.044352
C245_0 N245_0 0 1.43e-12
R245_1h N245_0 N246_0 0.058432
R245_1v N245_0 N345_0 0.026752
C246_0 N246_0 0 1.25e-12
R246_1h N246_0 N247_0 0.071104
R246_1v N246_0 N346_0 0.01408
C247_0 N247_0 0 1.18e-12
R247_1h N247_0 N248_0 0.019008
R247_1v N247_0 N347_0 0.032384
C248_0 N248_0 0 1.63e-12
R248_1h N248_0 N249_0 0.04576
R248_1v N248_0 N348_0 0.0704
C249_0 N249_0 0 1.58e-12
R249_1v N249_0 N349_0 0.02816
** row: 25
C250_0 N250_0 0 1.04e-12
R250_1h N250_0 N251_0 0.057024
R250_1v N250_0 N350_0 0.049984
C251_0 N251_0 0 1.33e-12
R251_1h N251_0 N252_0 0.06688
R251_1v N251_0 N351_0 0.069696
C252_0 N252_0 0 1.73e-12
R252_1h N252_0 N253_0 0.009856
R252_1v N252_0 N352_0 0.042944
C253_0 N253_0 0 1.05e-12
R253_1h N253_0 N254_0 0.04224
R253_1v N253_0 N353_0 0.054912
C254_0 N254_0 0 1.03e-12
R254_1h N254_0 N255_0 0.06688
R254_1v N254_0 N354_0 0.011264
C255_0 N255_0 0 1.95e-12
R255_1h N255_0 N256_0 0.034496
R255_1v N255_0 N355_0 0.041536
C256_0 N256_0 0 1.2e-12
R256_1h N256_0 N257_0 0.054208
R256_1v N256_0 N356_0 0.025344
C257_0 N257_0 0 1.63e-12
R257_1h N257_0 N258_0 0.061248
R257_1v N257_0 N357_0 0.074624
C258_0 N258_0 0 1.81e-12
R258_1h N258_0 N259_0 0.0528
R258_1v N258_0 N358_0 0.04928
C259_0 N259_0 0 1.36e-12
R259_1v N259_0 N359_0 0.04576
** row: 26
C260_0 N260_0 0 1.7e-12
R260_1h N260_0 N261_0 0.019712
R260_1v N260_0 N360_0 0.014784
C261_0 N261_0 0 1.42e-12
R261_1h N261_0 N262_0 0.029568
R261_1v N261_0 N361_0 0.074624
C262_0 N262_0 0 1.79e-12
R262_1h N262_0 N263_0 0.021824
R262_1v N262_0 N362_0 0.05632
C263_0 N263_0 0 1.84e-12
R263_1h N263_0 N264_0 0.057728
R263_1v N263_0 N363_0 0.026048
C264_0 N264_0 0 1.34e-12
R264_1h N264_0 N265_0 0.0352
R264_1v N264_0 N364_0 0.065472
C265_0 N265_0 0 1.72e-12
R265_1h N265_0 N266_0 0.076032
R265_1v N265_0 N365_0 0.02816
C266_0 N266_0 0 1.63e-12
R266_1h N266_0 N267_0 0.040128
R266_1v N266_0 N366_0 0.04224
C267_0 N267_0 0 1.3e-12
R267_1h N267_0 N268_0 0.058432
R267_1v N267_0 N367_0 0.016896
C268_0 N268_0 0 1.59e-12
R268_1h N268_0 N269_0 0.022528
R268_1v N268_0 N368_0 0.040128
C269_0 N269_0 0 1.24e-12
R269_1v N269_0 N369_0 0.064768
** row: 27
C270_0 N270_0 0 1.35e-12
R270_1h N270_0 N271_0 0.029568
R270_1v N270_0 N370_0 0.009856
C271_0 N271_0 0 1.54e-12
R271_1h N271_0 N272_0 0.037312
R271_1v N271_0 N371_0 0.076032
C272_0 N272_0 0 1.86e-12
R272_1h N272_0 N273_0 0.0352
R272_1v N272_0 N372_0 0.061952
C273_0 N273_0 0 1.59e-12
R273_1h N273_0 N274_0 0.050688
R273_1v N273_0 N373_0 0.050688
C274_0 N274_0 0 1.83e-12
R274_1h N274_0 N275_0 0.035904
R274_1v N274_0 N374_0 0.040832
C275_0 N275_0 0 1.23e-12
R275_1h N275_0 N276_0 0.023936
R275_1v N275_0 N375_0 0.057728
C276_0 N276_0 0 1.22e-12
R276_1h N276_0 N277_0 0.045056
R276_1v N276_0 N376_0 0.03168
C277_0 N277_0 0 1.21e-12
R277_1h N277_0 N278_0 0.047168
R277_1v N277_0 N377_0 0.0528
C278_0 N278_0 0 1.47e-12
R278_1h N278_0 N279_0 0.057024
R278_1v N278_0 N378_0 0.060544
C279_0 N279_0 0 1.69e-12
R279_1v N279_0 N379_0 0.019712
** row: 28
C280_0 N280_0 0 1.01e-12
R280_1h N280_0 N281_0 0.009152
R280_1v N280_0 N380_0 0.044352
C281_0 N281_0 0 1.33e-12
R281_1h N281_0 N282_0 0.011968
R281_1v N281_0 N381_0 0.048576
C282_0 N282_0 0 1.28e-12
R282_1h N282_0 N283_0 0.011264
R282_1v N282_0 N382_0 0.075328
C283_0 N283_0 0 1.2e-12
R283_1h N283_0 N284_0 0.066176
R283_1v N283_0 N383_0 0.012672
C284_0 N284_0 0 1.34e-12
R284_1h N284_0 N285_0 0.076032
R284_1v N284_0 N384_0 0.071104
C285_0 N285_0 0 1.76e-12
R285_1h N285_0 N286_0 0.076032
R285_1v N285_0 N385_0 0.0176
C286_0 N286_0 0 1.52e-12
R286_1h N286_0 N287_0 0.057024
R286_1v N286_0 N386_0 0.069696
C287_0 N287_0 0 1.59e-12
R287_1h N287_0 N288_0 0.011264
R287_1v N287_0 N387_0 0.01408
C288_0 N288_0 0 1.16e-12
R288_1h N288_0 N289_0 0.023936
R288_1v N288_0 N388_0 0.013376
C289_0 N289_0 0 1.39e-12
R289_1v N289_0 N389_0 0.00704
** row: 29
C290_0 N290_0 0 1.78e-12
R290_1h N290_0 N291_0 0.013376
R290_1v N290_0 N390_0 0.044352
C291_0 N291_0 0 1.81e-12
R291_1h N291_0 N292_0 0.016896
R291_1v N291_0 N391_0 0.033792
C292_0 N292_0 0 1.89e-12
R292_1h N292_0 N293_0 0.025344
R292_1v N292_0 N392_0 0.054208
C293_0 N293_0 0 1.47e-12
R293_1h N293_0 N294_0 0.023232
R293_1v N293_0 N393_0 0.068288
C294_0 N294_0 0 1.31e-12
R294_1h N294_0 N295_0 0.029568
R294_1v N294_0 N394_0 0.022528
C295_0 N295_0 0 1.81e-12
R295_1h N295_0 N296_0 0.05984
R295_1v N295_0 N395_0 0.04224
C296_0 N296_0 0 1.79e-12
R296_1h N296_0 N297_0 0.0704
R296_1v N296_0 N396_0 0.045056
C297_0 N297_0 0 1.5e-12
R297_1h N297_0 N298_0 0.028864
R297_1v N297_0 N397_0 0.016192
C298_0 N298_0 0 1.57e-12
R298_1h N298_0 N299_0 0.073216
R298_1v N298_0 N398_0 0.064064
C299_0 N299_0 0 1.81e-12
R299_1v N299_0 N399_0 0.009152
** row: 30
C300_0 N300_0 0 1.2e-12
R300_1h N300_0 N301_0 0.030272
R300_1v N300_0 N400_0 0.064768
C301_0 N301_0 0 1.81e-12
R301_1h N301_0 N302_0 0.068288
R301_1v N301_0 N401_0 0.0176
C302_0 N302_0 0 1.96e-12
R302_1h N302_0 N303_0 0.02464
R302_1v N302_0 N402_0 0.009856
C303_0 N303_0 0 1.22e-12
R303_1h N303_0 N304_0 0.071808
R303_1v N303_0 N403_0 0.042944
C304_0 N304_0 0 1.97e-12
R304_1h N304_0 N305_0 0.029568
R304_1v N304_0 N404_0 0.030976
C305_0 N305_0 0 1.81e-12
R305_1h N305_0 N306_0 0.011264
R305_1v N305_0 N405_0 0.0176
C306_0 N306_0 0 1.57e-12
R306_1h N306_0 N307_0 0.012672
R306_1v N306_0 N406_0 0.07392
C307_0 N307_0 0 1.99e-12
R307_1h N307_0 N308_0 0.050688
R307_1v N307_0 N407_0 0.075328
C308_0 N308_0 0 1.83e-12
R308_1h N308_0 N309_0 0.060544
R308_1v N308_0 N408_0 0.045056
C309_0 N309_0 0 1.77e-12
R309_1v N309_0 N409_0 0.013376
** row: 31
C310_0 N310_0 0 1.87e-12
R310_1h N310_0 N311_0 0.029568
R310_1v N310_0 N410_0 0.064768
C311_0 N311_0 0 1.21e-12
R311_1h N311_0 N312_0 0.053504
R311_1v N311_0 N411_0 0.051392
C312_0 N312_0 0 1.6e-12
R312_1h N312_0 N313_0 0.064768
R312_1v N312_0 N412_0 0.014784
C313_0 N313_0 0 1.85e-12
R313_1h N313_0 N314_0 0.067584
R313_1v N313_0 N413_0 0.06688
C314_0 N314_0 0 1.3e-12
R314_1h N314_0 N315_0 0.0704
R314_1v N314_0 N414_0 0.065472
C315_0 N315_0 0 1.14e-12
R315_1h N315_0 N316_0 0.060544
R315_1v N315_0 N415_0 0.018304
C316_0 N316_0 0 1.2e-12
R316_1h N316_0 N317_0 0.071808
R316_1v N316_0 N416_0 0.02464
C317_0 N317_0 0 1.28e-12
R317_1h N317_0 N318_0 0.034496
R317_1v N317_0 N417_0 0.02464
C318_0 N318_0 0 1.9e-12
R318_1h N318_0 N319_0 0.032384
R318_1v N318_0 N418_0 0.04928
C319_0 N319_0 0 1.18e-12
R319_1v N319_0 N419_0 0.037312
** row: 32
C320_0 N320_0 0 1.37e-12
R320_1h N320_0 N321_0 0.026752
R320_1v N320_0 N420_0 0.064768
C321_0 N321_0 0 1.21e-12
R321_1h N321_0 N322_0 0.01408
R321_1v N321_0 N421_0 0.04576
C322_0 N322_0 0 1.88e-12
R322_1h N322_0 N323_0 0.02464
R322_1v N322_0 N422_0 0.0176
C323_0 N323_0 0 1.7e-12
R323_1h N323_0 N324_0 0.033088
R323_1v N323_0 N423_0 0.044352
C324_0 N324_0 0 1.08e-12
R324_1h N324_0 N325_0 0.022528
R324_1v N324_0 N424_0 0.065472
C325_0 N325_0 0 1.5e-12
R325_1h N325_0 N326_0 0.047168
R325_1v N325_0 N425_0 0.075328
C326_0 N326_0 0 1.27e-12
R326_1h N326_0 N327_0 0.025344
R326_1v N326_0 N426_0 0.055616
C327_0 N327_0 0 1.71e-12
R327_1h N327_0 N328_0 0.042944
R327_1v N327_0 N427_0 0.041536
C328_0 N328_0 0 1.1e-12
R328_1h N328_0 N329_0 0.026752
R328_1v N328_0 N428_0 0.034496
C329_0 N329_0 0 1.98e-12
R329_1v N329_0 N429_0 0.068992
** row: 33
C330_0 N330_0 0 1.1e-12
R330_1h N330_0 N331_0 0.072512
R330_1v N330_0 N430_0 0.061248
C331_0 N331_0 0 1.9e-12
R331_1h N331_0 N332_0 0.060544
R331_1v N331_0 N431_0 0.076736
C332_0 N332_0 0 1.52e-12
R332_1h N332_0 N333_0 0.028864
R332_1v N332_0 N432_0 0.068288
C333_0 N333_0 0 1.77e-12
R333_1h N333_0 N334_0 0.076736
R333_1v N333_0 N433_0 0.047168
C334_0 N334_0 0 1.66e-12
R334_1h N334_0 N335_0 0.043648
R334_1v N334_0 N434_0 0.019008
C335_0 N335_0 0 1.41e-12
R335_1h N335_0 N336_0 0.03168
R335_1v N335_0 N435_0 0.054912
C336_0 N336_0 0 1.98e-12
R336_1h N336_0 N337_0 0.066176
R336_1v N336_0 N436_0 0.07392
C337_0 N337_0 0 1.76e-12
R337_1h N337_0 N338_0 0.01056
R337_1v N337_0 N437_0 0.053504
C338_0 N338_0 0 1.28e-12
R338_1h N338_0 N339_0 0.045056
R338_1v N338_0 N438_0 0.026752
C339_0 N339_0 0 1.08e-12
R339_1v N339_0 N439_0 0.072512
** row: 34
C340_0 N340_0 0 1.78e-12
R340_1h N340_0 N341_0 0.075328
R340_1v N340_0 N440_0 0.04576
C341_0 N341_0 0 1.72e-12
R341_1h N341_0 N342_0 0.059136
R341_1v N341_0 N441_0 0.03872
C342_0 N342_0 0 1e-12
R342_1h N342_0 N343_0 0.02464
R342_1v N342_0 N442_0 0.075328
C343_0 N343_0 0 1.83e-12
R343_1h N343_0 N344_0 0.015488
R343_1v N343_0 N443_0 0.026048
C344_0 N344_0 0 1.82e-12
R344_1h N344_0 N345_0 0.021824
R344_1v N344_0 N444_0 0.072512
C345_0 N345_0 0 1.34e-12
R345_1h N345_0 N346_0 0.034496
R345_1v N345_0 N445_0 0.030976
C346_0 N346_0 0 1.21e-12
R346_1h N346_0 N347_0 0.048576
R346_1v N346_0 N446_0 0.06688
C347_0 N347_0 0 1.57e-12
R347_1h N347_0 N348_0 0.045056
R347_1v N347_0 N447_0 0.049984
C348_0 N348_0 0 1.62e-12
R348_1h N348_0 N349_0 0.057728
R348_1v N348_0 N448_0 0.035904
C349_0 N349_0 0 1.16e-12
R349_1v N349_0 N449_0 0.043648
** row: 35
C350_0 N350_0 0 1.5e-12
R350_1h N350_0 N351_0 0.050688
R350_1v N350_0 N450_0 0.064768
C351_0 N351_0 0 1.99e-12
R351_1h N351_0 N352_0 0.019008
R351_1v N351_0 N451_0 0.045056
C352_0 N352_0 0 1.73e-12
R352_1h N352_0 N353_0 0.0176
R352_1v N352_0 N452_0 0.011264
C353_0 N353_0 0 1.51e-12
R353_1h N353_0 N354_0 0.052096
R353_1v N353_0 N453_0 0.0704
C354_0 N354_0 0 1.63e-12
R354_1h N354_0 N355_0 0.071104
R354_1v N354_0 N454_0 0.057728
C355_0 N355_0 0 1.37e-12
R355_1h N355_0 N356_0 0.033088
R355_1v N355_0 N455_0 0.048576
C356_0 N356_0 0 1.28e-12
R356_1h N356_0 N357_0 0.057024
R356_1v N356_0 N456_0 0.06336
C357_0 N357_0 0 1.87e-12
R357_1h N357_0 N358_0 0.046464
R357_1v N357_0 N457_0 0.0704
C358_0 N358_0 0 1.41e-12
R358_1h N358_0 N359_0 0.05632
R358_1v N358_0 N458_0 0.043648
C359_0 N359_0 0 1.65e-12
R359_1v N359_0 N459_0 0.014784
** row: 36
C360_0 N360_0 0 1.69e-12
R360_1h N360_0 N361_0 0.019008
R360_1v N360_0 N460_0 0.049984
C361_0 N361_0 0 1.83e-12
R361_1h N361_0 N362_0 0.042944
R361_1v N361_0 N461_0 0.015488
C362_0 N362_0 0 1e-12
R362_1h N362_0 N363_0 0.011264
R362_1v N362_0 N462_0 0.033792
C363_0 N363_0 0 1.67e-12
R363_1h N363_0 N364_0 0.052096
R363_1v N363_0 N463_0 0.069696
C364_0 N364_0 0 1.32e-12
R364_1h N364_0 N365_0 0.045056
R364_1v N364_0 N464_0 0.009856
C365_0 N365_0 0 1.75e-12
R365_1h N365_0 N366_0 0.062656
R365_1v N365_0 N465_0 0.035904
C366_0 N366_0 0 1.12e-12
R366_1h N366_0 N367_0 0.033792
R366_1v N366_0 N466_0 0.055616
C367_0 N367_0 0 1.36e-12
R367_1h N367_0 N368_0 0.05632
R367_1v N367_0 N467_0 0.046464
C368_0 N368_0 0 1.44e-12
R368_1h N368_0 N369_0 0.04928
R368_1v N368_0 N468_0 0.041536
C369_0 N369_0 0 1.14e-12
R369_1v N369_0 N469_0 0.0528
** row: 37
C370_0 N370_0 0 1.14e-12
R370_1h N370_0 N371_0 0.025344
R370_1v N370_0 N470_0 0.067584
C371_0 N371_0 0 1.83e-12
R371_1h N371_0 N372_0 0.034496
R371_1v N371_0 N471_0 0.055616
C372_0 N372_0 0 1.35e-12
R372_1h N372_0 N373_0 0.043648
R372_1v N372_0 N472_0 0.021824
C373_0 N373_0 0 1.93e-12
R373_1h N373_0 N374_0 0.0704
R373_1v N373_0 N473_0 0.069696
C374_0 N374_0 0 1.09e-12
R374_1h N374_0 N375_0 0.028864
R374_1v N374_0 N474_0 0.058432
C375_0 N375_0 0 1.64e-12
R375_1h N375_0 N376_0 0.03168
R375_1v N375_0 N475_0 0.040832
C376_0 N376_0 0 1.95e-12
R376_1h N376_0 N377_0 0.061248
R376_1v N376_0 N476_0 0.016192
C377_0 N377_0 0 1.33e-12
R377_1h N377_0 N378_0 0.076032
R377_1v N377_0 N477_0 0.041536
C378_0 N378_0 0 1.55e-12
R378_1h N378_0 N379_0 0.04576
R378_1v N378_0 N478_0 0.072512
C379_0 N379_0 0 1.68e-12
R379_1v N379_0 N479_0 0.046464
** row: 38
C380_0 N380_0 0 1.6e-12
R380_1h N380_0 N381_0 0.030272
R380_1v N380_0 N480_0 0.023232
C381_0 N381_0 0 1.86e-12
R381_1h N381_0 N382_0 0.057024
R381_1v N381_0 N481_0 0.047872
C382_0 N382_0 0 1.77e-12
R382_1h N382_0 N383_0 0.0352
R382_1v N382_0 N482_0 0.03872
C383_0 N383_0 0 1.81e-12
R383_1h N383_0 N384_0 0.049984
R383_1v N383_0 N483_0 0.0704
C384_0 N384_0 0 1.23e-12
R384_1h N384_0 N385_0 0.04224
R384_1v N384_0 N484_0 0.00704
C385_0 N385_0 0 1.54e-12
R385_1h N385_0 N386_0 0.05984
R385_1v N385_0 N485_0 0.052096
C386_0 N386_0 0 1.42e-12
R386_1h N386_0 N387_0 0.023936
R386_1v N386_0 N486_0 0.048576
C387_0 N387_0 0 1.19e-12
R387_1h N387_0 N388_0 0.069696
R387_1v N387_0 N487_0 0.038016
C388_0 N388_0 0 1.69e-12
R388_1h N388_0 N389_0 0.033792
R388_1v N388_0 N488_0 0.042944
C389_0 N389_0 0 1.76e-12
R389_1v N389_0 N489_0 0.065472
** row: 39
C390_0 N390_0 0 1.19e-12
R390_1h N390_0 N391_0 0.030272
R390_1v N390_0 N490_0 0.037312
C391_0 N391_0 0 1.04e-12
R391_1h N391_0 N392_0 0.046464
R391_1v N391_0 N491_0 0.064064
C392_0 N392_0 0 1.75e-12
R392_1h N392_0 N393_0 0.053504
R392_1v N392_0 N492_0 0.014784
C393_0 N393_0 0 1.67e-12
R393_1h N393_0 N394_0 0.015488
R393_1v N393_0 N493_0 0.071808
C394_0 N394_0 0 1.29e-12
R394_1h N394_0 N395_0 0.008448
R394_1v N394_0 N494_0 0.054912
C395_0 N395_0 0 1.31e-12
R395_1h N395_0 N396_0 0.008448
R395_1v N395_0 N495_0 0.059136
C396_0 N396_0 0 1.07e-12
R396_1h N396_0 N397_0 0.019712
R396_1v N396_0 N496_0 0.018304
C397_0 N397_0 0 1.83e-12
R397_1h N397_0 N398_0 0.061248
R397_1v N397_0 N497_0 0.068288
C398_0 N398_0 0 1.72e-12
R398_1h N398_0 N399_0 0.058432
R398_1v N398_0 N498_0 0.047168
C399_0 N399_0 0 1.62e-12
R399_1v N399_0 N499_0 0.02464
** row: 40
C400_0 N400_0 0 1.33e-12
R400_1h N400_0 N401_0 0.075328
R400_1v N400_0 N500_0 0.074624
C401_0 N401_0 0 1.18e-12
R401_1h N401_0 N402_0 0.035904
R401_1v N401_0 N501_0 0.044352
C402_0 N402_0 0 1.26e-12
R402_1h N402_0 N403_0 0.059136
R402_1v N402_0 N502_0 0.06336
C403_0 N403_0 0 1.93e-12
R403_1h N403_0 N404_0 0.06688
R403_1v N403_0 N503_0 0.040832
C404_0 N404_0 0 1.05e-12
R404_1h N404_0 N405_0 0.02816
R404_1v N404_0 N504_0 0.027456
C405_0 N405_0 0 1.59e-12
R405_1h N405_0 N406_0 0.076032
R405_1v N405_0 N505_0 0.04928
C406_0 N406_0 0 1.62e-12
R406_1h N406_0 N407_0 0.023936
R406_1v N406_0 N506_0 0.020416
C407_0 N407_0 0 1.8e-12
R407_1h N407_0 N408_0 0.035904
R407_1v N407_0 N507_0 0.008448
C408_0 N408_0 0 1.1e-12
R408_1h N408_0 N409_0 0.06336
R408_1v N408_0 N508_0 0.025344
C409_0 N409_0 0 1.83e-12
R409_1v N409_0 N509_0 0.069696
** row: 41
C410_0 N410_0 0 1.4e-12
R410_1h N410_0 N411_0 0.012672
R410_1v N410_0 N510_0 0.023232
C411_0 N411_0 0 1.38e-12
R411_1h N411_0 N412_0 0.047168
R411_1v N411_0 N511_0 0.072512
C412_0 N412_0 0 1.31e-12
R412_1h N412_0 N413_0 0.01408
R412_1v N412_0 N512_0 0.02112
C413_0 N413_0 0 1.05e-12
R413_1h N413_0 N414_0 0.0704
R413_1v N413_0 N513_0 0.016192
C414_0 N414_0 0 1.91e-12
R414_1h N414_0 N415_0 0.033792
R414_1v N414_0 N514_0 0.05632
C415_0 N415_0 0 1.21e-12
R415_1h N415_0 N416_0 0.054208
R415_1v N415_0 N515_0 0.027456
C416_0 N416_0 0 1.71e-12
R416_1h N416_0 N417_0 0.06336
R416_1v N416_0 N516_0 0.037312
C417_0 N417_0 0 1.95e-12
R417_1h N417_0 N418_0 0.076736
R417_1v N417_0 N517_0 0.023936
C418_0 N418_0 0 1.88e-12
R418_1h N418_0 N419_0 0.045056
R418_1v N418_0 N518_0 0.067584
C419_0 N419_0 0 1.69e-12
R419_1v N419_0 N519_0 0.029568
** row: 42
C420_0 N420_0 0 1.69e-12
R420_1h N420_0 N421_0 0.01408
R420_1v N420_0 N520_0 0.058432
C421_0 N421_0 0 1.3e-12
R421_1h N421_0 N422_0 0.030272
R421_1v N421_0 N521_0 0.051392
C422_0 N422_0 0 1.87e-12
R422_1h N422_0 N423_0 0.062656
R422_1v N422_0 N522_0 0.073216
C423_0 N423_0 0 1.49e-12
R423_1h N423_0 N424_0 0.076736
R423_1v N423_0 N523_0 0.042944
C424_0 N424_0 0 1.39e-12
R424_1h N424_0 N425_0 0.052096
R424_1v N424_0 N524_0 0.036608
C425_0 N425_0 0 1.3e-12
R425_1h N425_0 N426_0 0.067584
R425_1v N425_0 N525_0 0.0176
C426_0 N426_0 0 1.49e-12
R426_1h N426_0 N427_0 0.0176
R426_1v N426_0 N526_0 0.067584
C427_0 N427_0 0 1.81e-12
R427_1h N427_0 N428_0 0.014784
R427_1v N427_0 N527_0 0.030976
C428_0 N428_0 0 1.33e-12
R428_1h N428_0 N429_0 0.068288
R428_1v N428_0 N528_0 0.022528
C429_0 N429_0 0 1.87e-12
R429_1v N429_0 N529_0 0.058432
** row: 43
C430_0 N430_0 0 1.43e-12
R430_1h N430_0 N431_0 0.020416
R430_1v N430_0 N530_0 0.036608
C431_0 N431_0 0 1.54e-12
R431_1h N431_0 N432_0 0.038016
R431_1v N431_0 N531_0 0.023936
C432_0 N432_0 0 1.39e-12
R432_1h N432_0 N433_0 0.048576
R432_1v N432_0 N532_0 0.051392
C433_0 N433_0 0 1.18e-12
R433_1h N433_0 N434_0 0.044352
R433_1v N433_0 N533_0 0.015488
C434_0 N434_0 0 1.69e-12
R434_1h N434_0 N435_0 0.01056
R434_1v N434_0 N534_0 0.009856
C435_0 N435_0 0 1.33e-12
R435_1h N435_0 N436_0 0.076736
R435_1v N435_0 N535_0 0.030976
C436_0 N436_0 0 1.19e-12
R436_1h N436_0 N437_0 0.0176
R436_1v N436_0 N536_0 0.03168
C437_0 N437_0 0 1.87e-12
R437_1h N437_0 N438_0 0.044352
R437_1v N437_0 N537_0 0.055616
C438_0 N438_0 0 1.5e-12
R438_1h N438_0 N439_0 0.068288
R438_1v N438_0 N538_0 0.008448
C439_0 N439_0 0 1.37e-12
R439_1v N439_0 N539_0 0.050688
** row: 44
C440_0 N440_0 0 1.89e-12
R440_1h N440_0 N441_0 0.01408
R440_1v N440_0 N540_0 0.01056
C441_0 N441_0 0 1.6e-12
R441_1h N441_0 N442_0 0.009856
R441_1v N441_0 N541_0 0.014784
C442_0 N442_0 0 1.57e-12
R442_1h N442_0 N443_0 0.027456
R442_1v N442_0 N542_0 0.009152
C443_0 N443_0 0 1.16e-12
R443_1h N443_0 N444_0 0.071808
R443_1v N443_0 N543_0 0.021824
C444_0 N444_0 0 1.22e-12
R444_1h N444_0 N445_0 0.01056
R444_1v N444_0 N544_0 0.037312
C445_0 N445_0 0 1.79e-12
R445_1h N445_0 N446_0 0.049984
R445_1v N445_0 N545_0 0.026752
C446_0 N446_0 0 1.78e-12
R446_1h N446_0 N447_0 0.040128
R446_1v N446_0 N546_0 0.00704
C447_0 N447_0 0 1.45e-12
R447_1h N447_0 N448_0 0.064768
R447_1v N447_0 N547_0 0.068288
C448_0 N448_0 0 1.99e-12
R448_1h N448_0 N449_0 0.042944
R448_1v N448_0 N548_0 0.069696
C449_0 N449_0 0 1.86e-12
R449_1v N449_0 N549_0 0.044352
** row: 45
C450_0 N450_0 0 1.26e-12
R450_1h N450_0 N451_0 0.040832
R450_1v N450_0 N550_0 0.073216
C451_0 N451_0 0 1.36e-12
R451_1h N451_0 N452_0 0.011264
R451_1v N451_0 N551_0 0.011968
C452_0 N452_0 0 1.92e-12
R452_1h N452_0 N453_0 0.019008
R452_1v N452_0 N552_0 0.052096
C453_0 N453_0 0 1.21e-12
R453_1h N453_0 N454_0 0.02112
R453_1v N453_0 N553_0 0.06336
C454_0 N454_0 0 1.66e-12
R454_1h N454_0 N455_0 0.073216
R454_1v N454_0 N554_0 0.045056
C455_0 N455_0 0 1.23e-12
R455_1h N455_0 N456_0 0.033088
R455_1v N455_0 N555_0 0.030272
C456_0 N456_0 0 1.84e-12
R456_1h N456_0 N457_0 0.019008
R456_1v N456_0 N556_0 0.015488
C457_0 N457_0 0 1.31e-12
R457_1h N457_0 N458_0 0.019008
R457_1v N457_0 N557_0 0.013376
C458_0 N458_0 0 1.65e-12
R458_1h N458_0 N459_0 0.046464
R458_1v N458_0 N558_0 0.012672
C459_0 N459_0 0 1.69e-12
R459_1v N459_0 N559_0 0.03872
** row: 46
C460_0 N460_0 0 1.95e-12
R460_1h N460_0 N461_0 0.022528
R460_1v N460_0 N560_0 0.057024
C461_0 N461_0 0 1.95e-12
R461_1h N461_0 N462_0 0.055616
R461_1v N461_0 N561_0 0.048576
C462_0 N462_0 0 1.01e-12
R462_1h N462_0 N463_0 0.060544
R462_1v N462_0 N562_0 0.043648
C463_0 N463_0 0 1.71e-12
R463_1h N463_0 N464_0 0.0352
R463_1v N463_0 N563_0 0.02464
C464_0 N464_0 0 1.43e-12
R464_1h N464_0 N465_0 0.057728
R464_1v N464_0 N564_0 0.071104
C465_0 N465_0 0 1.89e-12
R465_1h N465_0 N466_0 0.026048
R465_1v N465_0 N565_0 0.053504
C466_0 N466_0 0 1.78e-12
R466_1h N466_0 N467_0 0.015488
R466_1v N466_0 N566_0 0.04224
C467_0 N467_0 0 1.96e-12
R467_1h N467_0 N468_0 0.023936
R467_1v N467_0 N567_0 0.030272
C468_0 N468_0 0 1.13e-12
R468_1h N468_0 N469_0 0.067584
R468_1v N468_0 N568_0 0.076736
C469_0 N469_0 0 1.7e-12
R469_1v N469_0 N569_0 0.073216
** row: 47
C470_0 N470_0 0 1.68e-12
R470_1h N470_0 N471_0 0.0176
R470_1v N470_0 N570_0 0.035904
C471_0 N471_0 0 1.42e-12
R471_1h N471_0 N472_0 0.034496
R471_1v N471_0 N571_0 0.033088
C472_0 N472_0 0 1.63e-12
R472_1h N472_0 N473_0 0.076032
R472_1v N472_0 N572_0 0.0704
C473_0 N473_0 0 1.39e-12
R473_1h N473_0 N474_0 0.008448
R473_1v N473_0 N573_0 0.016192
C474_0 N474_0 0 1.31e-12
R474_1h N474_0 N475_0 0.026752
R474_1v N474_0 N574_0 0.047168
C475_0 N475_0 0 1.04e-12
R475_1h N475_0 N476_0 0.057024
R475_1v N475_0 N575_0 0.039424
C476_0 N476_0 0 1.83e-12
R476_1h N476_0 N477_0 0.033792
R476_1v N476_0 N576_0 0.02464
C477_0 N477_0 0 1.95e-12
R477_1h N477_0 N478_0 0.0352
R477_1v N477_0 N577_0 0.021824
C478_0 N478_0 0 1.72e-12
R478_1h N478_0 N479_0 0.025344
R478_1v N478_0 N578_0 0.030976
C479_0 N479_0 0 1.58e-12
R479_1v N479_0 N579_0 0.02464
** row: 48
C480_0 N480_0 0 1.56e-12
R480_1h N480_0 N481_0 0.043648
R480_1v N480_0 N580_0 0.03872
C481_0 N481_0 0 1.72e-12
R481_1h N481_0 N482_0 0.039424
R481_1v N481_0 N581_0 0.034496
C482_0 N482_0 0 1.11e-12
R482_1h N482_0 N483_0 0.065472
R482_1v N482_0 N582_0 0.009152
C483_0 N483_0 0 1.61e-12
R483_1h N483_0 N484_0 0.02464
R483_1v N483_0 N583_0 0.036608
C484_0 N484_0 0 1.16e-12
R484_1h N484_0 N485_0 0.034496
R484_1v N484_0 N584_0 0.059136
C485_0 N485_0 0 1.44e-12
R485_1h N485_0 N486_0 0.074624
R485_1v N485_0 N585_0 0.02816
C486_0 N486_0 0 1.67e-12
R486_1h N486_0 N487_0 0.073216
R486_1v N486_0 N586_0 0.016192
C487_0 N487_0 0 1.57e-12
R487_1h N487_0 N488_0 0.020416
R487_1v N487_0 N587_0 0.04928
C488_0 N488_0 0 1.5e-12
R488_1h N488_0 N489_0 0.071808
R488_1v N488_0 N588_0 0.029568
C489_0 N489_0 0 1.76e-12
R489_1v N489_0 N589_0 0.062656
** row: 49
C490_0 N490_0 0 1.9e-12
R490_1h N490_0 N491_0 0.044352
R490_1v N490_0 N590_0 0.03168
C491_0 N491_0 0 1.95e-12
R491_1h N491_0 N492_0 0.076032
R491_1v N491_0 N591_0 0.011968
C492_0 N492_0 0 1.41e-12
R492_1h N492_0 N493_0 0.033088
R492_1v N492_0 N592_0 0.05632
C493_0 N493_0 0 1.76e-12
R493_1h N493_0 N494_0 0.0352
R493_1v N493_0 N593_0 0.066176
C494_0 N494_0 0 1.01e-12
R494_1h N494_0 N495_0 0.065472
R494_1v N494_0 N594_0 0.00704
C495_0 N495_0 0 1.92e-12
R495_1h N495_0 N496_0 0.013376
R495_1v N495_0 N595_0 0.074624
C496_0 N496_0 0 1.4e-12
R496_1h N496_0 N497_0 0.034496
R496_1v N496_0 N596_0 0.051392
C497_0 N497_0 0 1.35e-12
R497_1h N497_0 N498_0 0.009856
R497_1v N497_0 N597_0 0.058432
C498_0 N498_0 0 1.06e-12
R498_1h N498_0 N499_0 0.052096
R498_1v N498_0 N598_0 0.023232
C499_0 N499_0 0 1.51e-12
R499_1v N499_0 N599_0 0.041536
** row: 50
C500_0 N500_0 0 1.51e-12
R500_1h N500_0 N501_0 0.02816
R500_1v N500_0 N600_0 0.034496
C501_0 N501_0 0 1.04e-12
R501_1h N501_0 N502_0 0.0528
R501_1v N501_0 N601_0 0.067584
C502_0 N502_0 0 1.02e-12
R502_1h N502_0 N503_0 0.02464
R502_1v N502_0 N602_0 0.062656
C503_0 N503_0 0 1.91e-12
R503_1h N503_0 N504_0 0.040128
R503_1v N503_0 N603_0 0.011968
C504_0 N504_0 0 1.84e-12
R504_1h N504_0 N505_0 0.028864
R504_1v N504_0 N604_0 0.049984
C505_0 N505_0 0 1.19e-12
R505_1h N505_0 N506_0 0.028864
R505_1v N505_0 N605_0 0.044352
C506_0 N506_0 0 1.28e-12
R506_1h N506_0 N507_0 0.026048
R506_1v N506_0 N606_0 0.073216
C507_0 N507_0 0 1.19e-12
R507_1h N507_0 N508_0 0.037312
R507_1v N507_0 N607_0 0.064064
C508_0 N508_0 0 1.23e-12
R508_1h N508_0 N509_0 0.054912
R508_1v N508_0 N608_0 0.068288
C509_0 N509_0 0 1.39e-12
R509_1v N509_0 N609_0 0.037312
** row: 51
C510_0 N510_0 0 1.38e-12
R510_1h N510_0 N511_0 0.068992
R510_1v N510_0 N610_0 0.073216
C511_0 N511_0 0 1.2e-12
R511_1h N511_0 N512_0 0.06336
R511_1v N511_0 N611_0 0.076032
C512_0 N512_0 0 1.86e-12
R512_1h N512_0 N513_0 0.019712
R512_1v N512_0 N612_0 0.043648
C513_0 N513_0 0 1.63e-12
R513_1h N513_0 N514_0 0.076032
R513_1v N513_0 N613_0 0.07392
C514_0 N514_0 0 1.1e-12
R514_1h N514_0 N515_0 0.01056
R514_1v N514_0 N614_0 0.062656
C515_0 N515_0 0 1.42e-12
R515_1h N515_0 N516_0 0.053504
R515_1v N515_0 N615_0 0.076032
C516_0 N516_0 0 1.25e-12
R516_1h N516_0 N517_0 0.057728
R516_1v N516_0 N616_0 0.061952
C517_0 N517_0 0 1.53e-12
R517_1h N517_0 N518_0 0.053504
R517_1v N517_0 N617_0 0.075328
C518_0 N518_0 0 1.48e-12
R518_1h N518_0 N519_0 0.040128
R518_1v N518_0 N618_0 0.057728
C519_0 N519_0 0 1.16e-12
R519_1v N519_0 N619_0 0.067584
** row: 52
C520_0 N520_0 0 1.12e-12
R520_1h N520_0 N521_0 0.048576
R520_1v N520_0 N620_0 0.061248
C521_0 N521_0 0 1e-12
R521_1h N521_0 N522_0 0.044352
R521_1v N521_0 N621_0 0.075328
C522_0 N522_0 0 1.32e-12
R522_1h N522_0 N523_0 0.009152
R522_1v N522_0 N622_0 0.03168
C523_0 N523_0 0 1.51e-12
R523_1h N523_0 N524_0 0.011968
R523_1v N523_0 N623_0 0.076032
C524_0 N524_0 0 1.49e-12
R524_1h N524_0 N525_0 0.045056
R524_1v N524_0 N624_0 0.049984
C525_0 N525_0 0 1.06e-12
R525_1h N525_0 N526_0 0.030976
R525_1v N525_0 N625_0 0.009152
C526_0 N526_0 0 1.25e-12
R526_1h N526_0 N527_0 0.066176
R526_1v N526_0 N626_0 0.026752
C527_0 N527_0 0 1.97e-12
R527_1h N527_0 N528_0 0.051392
R527_1v N527_0 N627_0 0.030272
C528_0 N528_0 0 1.15e-12
R528_1h N528_0 N529_0 0.04928
R528_1v N528_0 N628_0 0.064064
C529_0 N529_0 0 1.14e-12
R529_1v N529_0 N629_0 0.06688
** row: 53
C530_0 N530_0 0 1.97e-12
R530_1h N530_0 N531_0 0.00704
R530_1v N530_0 N630_0 0.075328
C531_0 N531_0 0 1.08e-12
R531_1h N531_0 N532_0 0.027456
R531_1v N531_0 N631_0 0.041536
C532_0 N532_0 0 1.13e-12
R532_1h N532_0 N533_0 0.062656
R532_1v N532_0 N632_0 0.030976
C533_0 N533_0 0 1.16e-12
R533_1h N533_0 N534_0 0.016896
R533_1v N533_0 N633_0 0.06688
C534_0 N534_0 0 1.75e-12
R534_1h N534_0 N535_0 0.0528
R534_1v N534_0 N634_0 0.067584
C535_0 N535_0 0 1.3e-12
R535_1h N535_0 N536_0 0.025344
R535_1v N535_0 N635_0 0.071808
C536_0 N536_0 0 1.16e-12
R536_1h N536_0 N537_0 0.027456
R536_1v N536_0 N636_0 0.055616
C537_0 N537_0 0 1.52e-12
R537_1h N537_0 N538_0 0.013376
R537_1v N537_0 N637_0 0.053504
C538_0 N538_0 0 1.15e-12
R538_1h N538_0 N539_0 0.07392
R538_1v N538_0 N638_0 0.030272
C539_0 N539_0 0 1.28e-12
R539_1v N539_0 N639_0 0.060544
** row: 54
C540_0 N540_0 0 1.47e-12
R540_1h N540_0 N541_0 0.016192
R540_1v N540_0 N640_0 0.025344
C541_0 N541_0 0 1e-12
R541_1h N541_0 N542_0 0.050688
R541_1v N541_0 N641_0 0.067584
C542_0 N542_0 0 1.29e-12
R542_1h N542_0 N543_0 0.051392
R542_1v N542_0 N642_0 0.00704
C543_0 N543_0 0 1.08e-12
R543_1h N543_0 N544_0 0.075328
R543_1v N543_0 N643_0 0.018304
C544_0 N544_0 0 1.75e-12
R544_1h N544_0 N545_0 0.064768
R544_1v N544_0 N644_0 0.038016
C545_0 N545_0 0 1.4e-12
R545_1h N545_0 N546_0 0.02112
R545_1v N545_0 N645_0 0.025344
C546_0 N546_0 0 1.18e-12
R546_1h N546_0 N547_0 0.0528
R546_1v N546_0 N646_0 0.073216
C547_0 N547_0 0 1.99e-12
R547_1h N547_0 N548_0 0.030976
R547_1v N547_0 N647_0 0.039424
C548_0 N548_0 0 1.08e-12
R548_1h N548_0 N549_0 0.044352
R548_1v N548_0 N648_0 0.050688
C549_0 N549_0 0 1.03e-12
R549_1v N549_0 N649_0 0.067584
** row: 55
C550_0 N550_0 0 1.42e-12
R550_1h N550_0 N551_0 0.029568
R550_1v N550_0 N650_0 0.030976
C551_0 N551_0 0 1.07e-12
R551_1h N551_0 N552_0 0.01408
R551_1v N551_0 N651_0 0.030976
C552_0 N552_0 0 1.69e-12
R552_1h N552_0 N553_0 0.074624
R552_1v N552_0 N652_0 0.0176
C553_0 N553_0 0 1.84e-12
R553_1h N553_0 N554_0 0.074624
R553_1v N553_0 N653_0 0.023936
C554_0 N554_0 0 1.82e-12
R554_1h N554_0 N555_0 0.0528
R554_1v N554_0 N654_0 0.042944
C555_0 N555_0 0 1.16e-12
R555_1h N555_0 N556_0 0.049984
R555_1v N555_0 N655_0 0.037312
C556_0 N556_0 0 1.37e-12
R556_1h N556_0 N557_0 0.068288
R556_1v N556_0 N656_0 0.049984
C557_0 N557_0 0 1.02e-12
R557_1h N557_0 N558_0 0.064064
R557_1v N557_0 N657_0 0.04928
C558_0 N558_0 0 1.88e-12
R558_1h N558_0 N559_0 0.062656
R558_1v N558_0 N658_0 0.02112
C559_0 N559_0 0 1.41e-12
R559_1v N559_0 N659_0 0.072512
** row: 56
C560_0 N560_0 0 1.24e-12
R560_1h N560_0 N561_0 0.026752
R560_1v N560_0 N660_0 0.03168
C561_0 N561_0 0 1.08e-12
R561_1h N561_0 N562_0 0.050688
R561_1v N561_0 N661_0 0.036608
C562_0 N562_0 0 1.7e-12
R562_1h N562_0 N563_0 0.074624
R562_1v N562_0 N662_0 0.051392
C563_0 N563_0 0 1.66e-12
R563_1h N563_0 N564_0 0.014784
R563_1v N563_0 N663_0 0.00704
C564_0 N564_0 0 1.15e-12
R564_1h N564_0 N565_0 0.068288
R564_1v N564_0 N664_0 0.030976
C565_0 N565_0 0 1.32e-12
R565_1h N565_0 N566_0 0.0704
R565_1v N565_0 N665_0 0.04224
C566_0 N566_0 0 1.93e-12
R566_1h N566_0 N567_0 0.030272
R566_1v N566_0 N666_0 0.034496
C567_0 N567_0 0 1.8e-12
R567_1h N567_0 N568_0 0.073216
R567_1v N567_0 N667_0 0.072512
C568_0 N568_0 0 1.13e-12
R568_1h N568_0 N569_0 0.045056
R568_1v N568_0 N668_0 0.064768
C569_0 N569_0 0 1.44e-12
R569_1v N569_0 N669_0 0.05984
** row: 57
C570_0 N570_0 0 1.23e-12
R570_1h N570_0 N571_0 0.033792
R570_1v N570_0 N670_0 0.042944
C571_0 N571_0 0 1.51e-12
R571_1h N571_0 N572_0 0.058432
R571_1v N571_0 N671_0 0.014784
C572_0 N572_0 0 1.65e-12
R572_1h N572_0 N573_0 0.054912
R572_1v N572_0 N672_0 0.064064
C573_0 N573_0 0 1.13e-12
R573_1h N573_0 N574_0 0.065472
R573_1v N573_0 N673_0 0.076736
C574_0 N574_0 0 1.77e-12
R574_1h N574_0 N575_0 0.03168
R574_1v N574_0 N674_0 0.016896
C575_0 N575_0 0 1.64e-12
R575_1h N575_0 N576_0 0.055616
R575_1v N575_0 N675_0 0.039424
C576_0 N576_0 0 1.07e-12
R576_1h N576_0 N577_0 0.057728
R576_1v N576_0 N676_0 0.071104
C577_0 N577_0 0 1.4e-12
R577_1h N577_0 N578_0 0.014784
R577_1v N577_0 N677_0 0.023232
C578_0 N578_0 0 1.87e-12
R578_1h N578_0 N579_0 0.047168
R578_1v N578_0 N678_0 0.032384
C579_0 N579_0 0 1.93e-12
R579_1v N579_0 N679_0 0.034496
** row: 58
C580_0 N580_0 0 1.81e-12
R580_1h N580_0 N581_0 0.02112
R580_1v N580_0 N680_0 0.016896
C581_0 N581_0 0 1.71e-12
R581_1h N581_0 N582_0 0.057024
R581_1v N581_0 N681_0 0.019712
C582_0 N582_0 0 1.96e-12
R582_1h N582_0 N583_0 0.030976
R582_1v N582_0 N682_0 0.065472
C583_0 N583_0 0 1.64e-12
R583_1h N583_0 N584_0 0.054208
R583_1v N583_0 N683_0 0.075328
C584_0 N584_0 0 1e-12
R584_1h N584_0 N585_0 0.054208
R584_1v N584_0 N684_0 0.059136
C585_0 N585_0 0 1.35e-12
R585_1h N585_0 N586_0 0.030272
R585_1v N585_0 N685_0 0.0704
C586_0 N586_0 0 1.57e-12
R586_1h N586_0 N587_0 0.029568
R586_1v N586_0 N686_0 0.041536
C587_0 N587_0 0 1.29e-12
R587_1h N587_0 N588_0 0.023232
R587_1v N587_0 N687_0 0.0704
C588_0 N588_0 0 1.92e-12
R588_1h N588_0 N589_0 0.040128
R588_1v N588_0 N688_0 0.027456
C589_0 N589_0 0 1.49e-12
R589_1v N589_0 N689_0 0.03168
** row: 59
C590_0 N590_0 0 1.22e-12
R590_1h N590_0 N591_0 0.0352
R590_1v N590_0 N690_0 0.054912
C591_0 N591_0 0 1.43e-12
R591_1h N591_0 N592_0 0.04576
R591_1v N591_0 N691_0 0.034496
C592_0 N592_0 0 1.66e-12
R592_1h N592_0 N593_0 0.02464
R592_1v N592_0 N692_0 0.032384
C593_0 N593_0 0 1.53e-12
R593_1h N593_0 N594_0 0.04928
R593_1v N593_0 N693_0 0.043648
C594_0 N594_0 0 1.2e-12
R594_1h N594_0 N595_0 0.047168
R594_1v N594_0 N694_0 0.009856
C595_0 N595_0 0 1.87e-12
R595_1h N595_0 N596_0 0.065472
R595_1v N595_0 N695_0 0.0352
C596_0 N596_0 0 1.21e-12
R596_1h N596_0 N597_0 0.025344
R596_1v N596_0 N696_0 0.075328
C597_0 N597_0 0 1.05e-12
R597_1h N597_0 N598_0 0.026048
R597_1v N597_0 N697_0 0.061952
C598_0 N598_0 0 1.28e-12
R598_1h N598_0 N599_0 0.055616
R598_1v N598_0 N698_0 0.05632
C599_0 N599_0 0 1.27e-12
R599_1v N599_0 N699_0 0.076032
** row: 60
C600_0 N600_0 0 1.2e-12
R600_1h N600_0 N601_0 0.051392
R600_1v N600_0 N700_0 0.021824
C601_0 N601_0 0 1.6e-12
R601_1h N601_0 N602_0 0.065472
R601_1v N601_0 N701_0 0.018304
C602_0 N602_0 0 1.67e-12
R602_1h N602_0 N603_0 0.023232
R602_1v N602_0 N702_0 0.064768
C603_0 N603_0 0 1.92e-12
R603_1h N603_0 N604_0 0.014784
R603_1v N603_0 N703_0 0.03168
C604_0 N604_0 0 1.53e-12
R604_1h N604_0 N605_0 0.051392
R604_1v N604_0 N704_0 0.012672
C605_0 N605_0 0 1.62e-12
R605_1h N605_0 N606_0 0.054912
R605_1v N605_0 N705_0 0.07392
C606_0 N606_0 0 1.98e-12
R606_1h N606_0 N607_0 0.04928
R606_1v N606_0 N706_0 0.054912
C607_0 N607_0 0 1.76e-12
R607_1h N607_0 N608_0 0.013376
R607_1v N607_0 N707_0 0.058432
C608_0 N608_0 0 1.03e-12
R608_1h N608_0 N609_0 0.068288
R608_1v N608_0 N708_0 0.045056
C609_0 N609_0 0 1.73e-12
R609_1v N609_0 N709_0 0.047168
** row: 61
C610_0 N610_0 0 1.81e-12
R610_1h N610_0 N611_0 0.023232
R610_1v N610_0 N710_0 0.027456
C611_0 N611_0 0 1.96e-12
R611_1h N611_0 N612_0 0.038016
R611_1v N611_0 N711_0 0.036608
C612_0 N612_0 0 1.8e-12
R612_1h N612_0 N613_0 0.015488
R612_1v N612_0 N712_0 0.013376
C613_0 N613_0 0 1.55e-12
R613_1h N613_0 N614_0 0.040128
R613_1v N613_0 N713_0 0.045056
C614_0 N614_0 0 1.66e-12
R614_1h N614_0 N615_0 0.030976
R614_1v N614_0 N714_0 0.048576
C615_0 N615_0 0 1.81e-12
R615_1h N615_0 N616_0 0.036608
R615_1v N615_0 N715_0 0.058432
C616_0 N616_0 0 1.01e-12
R616_1h N616_0 N617_0 0.033792
R616_1v N616_0 N716_0 0.057024
C617_0 N617_0 0 1.13e-12
R617_1h N617_0 N618_0 0.047872
R617_1v N617_0 N717_0 0.076736
C618_0 N618_0 0 1.22e-12
R618_1h N618_0 N619_0 0.066176
R618_1v N618_0 N718_0 0.04576
C619_0 N619_0 0 1.61e-12
R619_1v N619_0 N719_0 0.0704
** row: 62
C620_0 N620_0 0 1.8e-12
R620_1h N620_0 N621_0 0.057024
R620_1v N620_0 N720_0 0.023232
C621_0 N621_0 0 1.03e-12
R621_1h N621_0 N622_0 0.00704
R621_1v N621_0 N721_0 0.02112
C622_0 N622_0 0 1e-12
R622_1h N622_0 N623_0 0.036608
R622_1v N622_0 N722_0 0.043648
C623_0 N623_0 0 1.12e-12
R623_1h N623_0 N624_0 0.009856
R623_1v N623_0 N723_0 0.011968
C624_0 N624_0 0 1.59e-12
R624_1h N624_0 N625_0 0.047872
R624_1v N624_0 N724_0 0.02464
C625_0 N625_0 0 1.94e-12
R625_1h N625_0 N626_0 0.019008
R625_1v N625_0 N725_0 0.047872
C626_0 N626_0 0 1.36e-12
R626_1h N626_0 N627_0 0.0704
R626_1v N626_0 N726_0 0.04928
C627_0 N627_0 0 1.26e-12
R627_1h N627_0 N628_0 0.016896
R627_1v N627_0 N727_0 0.058432
C628_0 N628_0 0 1.37e-12
R628_1h N628_0 N629_0 0.0528
R628_1v N628_0 N728_0 0.040832
C629_0 N629_0 0 1.21e-12
R629_1v N629_0 N729_0 0.02112
** row: 63
C630_0 N630_0 0 1.09e-12
R630_1h N630_0 N631_0 0.051392
R630_1v N630_0 N730_0 0.00704
C631_0 N631_0 0 1.32e-12
R631_1h N631_0 N632_0 0.067584
R631_1v N631_0 N731_0 0.009856
C632_0 N632_0 0 1.33e-12
R632_1h N632_0 N633_0 0.047872
R632_1v N632_0 N732_0 0.046464
C633_0 N633_0 0 1.27e-12
R633_1h N633_0 N634_0 0.01408
R633_1v N633_0 N733_0 0.054912
C634_0 N634_0 0 1.31e-12
R634_1h N634_0 N635_0 0.055616
R634_1v N634_0 N734_0 0.026752
C635_0 N635_0 0 1.41e-12
R635_1h N635_0 N636_0 0.039424
R635_1v N635_0 N735_0 0.059136
C636_0 N636_0 0 1.58e-12
R636_1h N636_0 N637_0 0.01056
R636_1v N636_0 N736_0 0.01408
C637_0 N637_0 0 1.01e-12
R637_1h N637_0 N638_0 0.0528
R637_1v N637_0 N737_0 0.069696
C638_0 N638_0 0 1.67e-12
R638_1h N638_0 N639_0 0.0704
R638_1v N638_0 N738_0 0.025344
C639_0 N639_0 0 1.32e-12
R639_1v N639_0 N739_0 0.033792
** row: 64
C640_0 N640_0 0 1.99e-12
R640_1h N640_0 N641_0 0.01056
R640_1v N640_0 N740_0 0.00704
C641_0 N641_0 0 1.62e-12
R641_1h N641_0 N642_0 0.047168
R641_1v N641_0 N741_0 0.029568
C642_0 N642_0 0 1.48e-12
R642_1h N642_0 N643_0 0.049984
R642_1v N642_0 N742_0 0.019008
C643_0 N643_0 0 1.07e-12
R643_1h N643_0 N644_0 0.055616
R643_1v N643_0 N743_0 0.075328
C644_0 N644_0 0 1.69e-12
R644_1h N644_0 N645_0 0.033792
R644_1v N644_0 N744_0 0.026752
C645_0 N645_0 0 1.39e-12
R645_1h N645_0 N646_0 0.019712
R645_1v N645_0 N745_0 0.05632
C646_0 N646_0 0 1.85e-12
R646_1h N646_0 N647_0 0.071808
R646_1v N646_0 N746_0 0.06336
C647_0 N647_0 0 1.42e-12
R647_1h N647_0 N648_0 0.045056
R647_1v N647_0 N747_0 0.030272
C648_0 N648_0 0 1.07e-12
R648_1h N648_0 N649_0 0.037312
R648_1v N648_0 N748_0 0.00704
C649_0 N649_0 0 1.5e-12
R649_1v N649_0 N749_0 0.021824
** row: 65
C650_0 N650_0 0 1.85e-12
R650_1h N650_0 N651_0 0.068992
R650_1v N650_0 N750_0 0.02112
C651_0 N651_0 0 1.9e-12
R651_1h N651_0 N652_0 0.0352
R651_1v N651_0 N751_0 0.030976
C652_0 N652_0 0 1.47e-12
R652_1h N652_0 N653_0 0.02464
R652_1v N652_0 N752_0 0.065472
C653_0 N653_0 0 1.61e-12
R653_1h N653_0 N654_0 0.073216
R653_1v N653_0 N753_0 0.036608
C654_0 N654_0 0 1.3e-12
R654_1h N654_0 N655_0 0.071104
R654_1v N654_0 N754_0 0.051392
C655_0 N655_0 0 1.2e-12
R655_1h N655_0 N656_0 0.02112
R655_1v N655_0 N755_0 0.045056
C656_0 N656_0 0 1.38e-12
R656_1h N656_0 N657_0 0.036608
R656_1v N656_0 N756_0 0.071808
C657_0 N657_0 0 1.3e-12
R657_1h N657_0 N658_0 0.022528
R657_1v N657_0 N757_0 0.030976
C658_0 N658_0 0 1.85e-12
R658_1h N658_0 N659_0 0.012672
R658_1v N658_0 N758_0 0.073216
C659_0 N659_0 0 1.8e-12
R659_1v N659_0 N759_0 0.012672
** row: 66
C660_0 N660_0 0 1.44e-12
R660_1h N660_0 N661_0 0.008448
R660_1v N660_0 N760_0 0.03872
C661_0 N661_0 0 1.84e-12
R661_1h N661_0 N662_0 0.022528
R661_1v N661_0 N761_0 0.068288
C662_0 N662_0 0 1.25e-12
R662_1h N662_0 N663_0 0.047168
R662_1v N662_0 N762_0 0.03168
C663_0 N663_0 0 1.02e-12
R663_1h N663_0 N664_0 0.071808
R663_1v N663_0 N763_0 0.040832
C664_0 N664_0 0 1.96e-12
R664_1h N664_0 N665_0 0.067584
R664_1v N664_0 N764_0 0.02816
C665_0 N665_0 0 1.4e-12
R665_1h N665_0 N666_0 0.041536
R665_1v N665_0 N765_0 0.042944
C666_0 N666_0 0 1.12e-12
R666_1h N666_0 N667_0 0.046464
R666_1v N666_0 N766_0 0.069696
C667_0 N667_0 0 1.54e-12
R667_1h N667_0 N668_0 0.040832
R667_1v N667_0 N767_0 0.057728
C668_0 N668_0 0 1.28e-12
R668_1h N668_0 N669_0 0.064768
R668_1v N668_0 N768_0 0.047168
C669_0 N669_0 0 1.88e-12
R669_1v N669_0 N769_0 0.060544
** row: 67
C670_0 N670_0 0 1.37e-12
R670_1h N670_0 N671_0 0.075328
R670_1v N670_0 N770_0 0.02112
C671_0 N671_0 0 1.39e-12
R671_1h N671_0 N672_0 0.073216
R671_1v N671_0 N771_0 0.01056
C672_0 N672_0 0 1.14e-12
R672_1h N672_0 N673_0 0.064768
R672_1v N672_0 N772_0 0.064768
C673_0 N673_0 0 1.23e-12
R673_1h N673_0 N674_0 0.055616
R673_1v N673_0 N773_0 0.032384
C674_0 N674_0 0 1.15e-12
R674_1h N674_0 N675_0 0.019008
R674_1v N674_0 N774_0 0.066176
C675_0 N675_0 0 1.53e-12
R675_1h N675_0 N676_0 0.076736
R675_1v N675_0 N775_0 0.023936
C676_0 N676_0 0 1.54e-12
R676_1h N676_0 N677_0 0.04224
R676_1v N676_0 N776_0 0.032384
C677_0 N677_0 0 1.1e-12
R677_1h N677_0 N678_0 0.071808
R677_1v N677_0 N777_0 0.036608
C678_0 N678_0 0 1.58e-12
R678_1h N678_0 N679_0 0.052096
R678_1v N678_0 N778_0 0.023232
C679_0 N679_0 0 1.41e-12
R679_1v N679_0 N779_0 0.021824
** row: 68
C680_0 N680_0 0 1.11e-12
R680_1h N680_0 N681_0 0.055616
R680_1v N680_0 N780_0 0.01408
C681_0 N681_0 0 1.6e-12
R681_1h N681_0 N682_0 0.0704
R681_1v N681_0 N781_0 0.008448
C682_0 N682_0 0 1.55e-12
R682_1h N682_0 N683_0 0.040128
R682_1v N682_0 N782_0 0.018304
C683_0 N683_0 0 1.89e-12
R683_1h N683_0 N684_0 0.064064
R683_1v N683_0 N783_0 0.034496
C684_0 N684_0 0 1.58e-12
R684_1h N684_0 N685_0 0.019008
R684_1v N684_0 N784_0 0.011264
C685_0 N685_0 0 1.75e-12
R685_1h N685_0 N686_0 0.007744
R685_1v N685_0 N785_0 0.014784
C686_0 N686_0 0 1.74e-12
R686_1h N686_0 N687_0 0.061952
R686_1v N686_0 N786_0 0.0528
C687_0 N687_0 0 1.77e-12
R687_1h N687_0 N688_0 0.053504
R687_1v N687_0 N787_0 0.060544
C688_0 N688_0 0 1.69e-12
R688_1h N688_0 N689_0 0.049984
R688_1v N688_0 N788_0 0.030976
C689_0 N689_0 0 1.33e-12
R689_1v N689_0 N789_0 0.032384
** row: 69
C690_0 N690_0 0 1.27e-12
R690_1h N690_0 N691_0 0.011264
R690_1v N690_0 N790_0 0.076736
C691_0 N691_0 0 1.97e-12
R691_1h N691_0 N692_0 0.018304
R691_1v N691_0 N791_0 0.04928
C692_0 N692_0 0 1.39e-12
R692_1h N692_0 N693_0 0.05632
R692_1v N692_0 N792_0 0.054208
C693_0 N693_0 0 1.86e-12
R693_1h N693_0 N694_0 0.067584
R693_1v N693_0 N793_0 0.012672
C694_0 N694_0 0 1.67e-12
R694_1h N694_0 N695_0 0.061248
R694_1v N694_0 N794_0 0.053504
C695_0 N695_0 0 1.36e-12
R695_1h N695_0 N696_0 0.03168
R695_1v N695_0 N795_0 0.072512
C696_0 N696_0 0 1.37e-12
R696_1h N696_0 N697_0 0.039424
R696_1v N696_0 N796_0 0.020416
C697_0 N697_0 0 1.67e-12
R697_1h N697_0 N698_0 0.015488
R697_1v N697_0 N797_0 0.074624
C698_0 N698_0 0 1.34e-12
R698_1h N698_0 N699_0 0.0352
R698_1v N698_0 N798_0 0.019008
C699_0 N699_0 0 1.95e-12
R699_1v N699_0 N799_0 0.059136
** row: 70
C700_0 N700_0 0 1.5e-12
R700_1h N700_0 N701_0 0.028864
R700_1v N700_0 N800_0 0.008448
C701_0 N701_0 0 1.08e-12
R701_1h N701_0 N702_0 0.02816
R701_1v N701_0 N801_0 0.042944
C702_0 N702_0 0 1.25e-12
R702_1h N702_0 N703_0 0.036608
R702_1v N702_0 N802_0 0.0704
C703_0 N703_0 0 1.47e-12
R703_1h N703_0 N704_0 0.049984
R703_1v N703_0 N803_0 0.060544
C704_0 N704_0 0 1.34e-12
R704_1h N704_0 N705_0 0.055616
R704_1v N704_0 N804_0 0.07392
C705_0 N705_0 0 1.63e-12
R705_1h N705_0 N706_0 0.03168
R705_1v N705_0 N805_0 0.028864
C706_0 N706_0 0 1.51e-12
R706_1h N706_0 N707_0 0.06336
R706_1v N706_0 N806_0 0.02112
C707_0 N707_0 0 1.97e-12
R707_1h N707_0 N708_0 0.00704
R707_1v N707_0 N807_0 0.068992
C708_0 N708_0 0 1.61e-12
R708_1h N708_0 N709_0 0.074624
R708_1v N708_0 N808_0 0.059136
C709_0 N709_0 0 1.01e-12
R709_1v N709_0 N809_0 0.016896
** row: 71
C710_0 N710_0 0 1.69e-12
R710_1h N710_0 N711_0 0.026752
R710_1v N710_0 N810_0 0.018304
C711_0 N711_0 0 1.52e-12
R711_1h N711_0 N712_0 0.064768
R711_1v N711_0 N811_0 0.02464
C712_0 N712_0 0 1.82e-12
R712_1h N712_0 N713_0 0.030272
R712_1v N712_0 N812_0 0.008448
C713_0 N713_0 0 1.77e-12
R713_1h N713_0 N714_0 0.023232
R713_1v N713_0 N813_0 0.041536
C714_0 N714_0 0 1.9e-12
R714_1h N714_0 N715_0 0.042944
R714_1v N714_0 N814_0 0.03168
C715_0 N715_0 0 1.6e-12
R715_1h N715_0 N716_0 0.039424
R715_1v N715_0 N815_0 0.076736
C716_0 N716_0 0 1.47e-12
R716_1h N716_0 N717_0 0.027456
R716_1v N716_0 N816_0 0.008448
C717_0 N717_0 0 1.28e-12
R717_1h N717_0 N718_0 0.041536
R717_1v N717_0 N817_0 0.076736
C718_0 N718_0 0 1.28e-12
R718_1h N718_0 N719_0 0.069696
R718_1v N718_0 N818_0 0.016192
C719_0 N719_0 0 1.76e-12
R719_1v N719_0 N819_0 0.051392
** row: 72
C720_0 N720_0 0 1.66e-12
R720_1h N720_0 N721_0 0.0704
R720_1v N720_0 N820_0 0.066176
C721_0 N721_0 0 1.94e-12
R721_1h N721_0 N722_0 0.048576
R721_1v N721_0 N821_0 0.032384
C722_0 N722_0 0 1.76e-12
R722_1h N722_0 N723_0 0.066176
R722_1v N722_0 N822_0 0.057024
C723_0 N723_0 0 1.09e-12
R723_1h N723_0 N724_0 0.033792
R723_1v N723_0 N823_0 0.00704
C724_0 N724_0 0 1.84e-12
R724_1h N724_0 N725_0 0.034496
R724_1v N724_0 N824_0 0.0704
C725_0 N725_0 0 1.35e-12
R725_1h N725_0 N726_0 0.05984
R725_1v N725_0 N825_0 0.04224
C726_0 N726_0 0 1.81e-12
R726_1h N726_0 N727_0 0.025344
R726_1v N726_0 N826_0 0.04224
C727_0 N727_0 0 1.62e-12
R727_1h N727_0 N728_0 0.026752
R727_1v N727_0 N827_0 0.061952
C728_0 N728_0 0 1.64e-12
R728_1h N728_0 N729_0 0.062656
R728_1v N728_0 N828_0 0.047872
C729_0 N729_0 0 1.53e-12
R729_1v N729_0 N829_0 0.038016
** row: 73
C730_0 N730_0 0 1.34e-12
R730_1h N730_0 N731_0 0.055616
R730_1v N730_0 N830_0 0.014784
C731_0 N731_0 0 1.77e-12
R731_1h N731_0 N732_0 0.01056
R731_1v N731_0 N831_0 0.047168
C732_0 N732_0 0 1.36e-12
R732_1h N732_0 N733_0 0.036608
R732_1v N732_0 N832_0 0.030976
C733_0 N733_0 0 1.72e-12
R733_1h N733_0 N734_0 0.0528
R733_1v N733_0 N833_0 0.07392
C734_0 N734_0 0 1.1e-12
R734_1h N734_0 N735_0 0.0528
R734_1v N734_0 N834_0 0.029568
C735_0 N735_0 0 1.49e-12
R735_1h N735_0 N736_0 0.011968
R735_1v N735_0 N835_0 0.054208
C736_0 N736_0 0 1.76e-12
R736_1h N736_0 N737_0 0.047872
R736_1v N736_0 N836_0 0.007744
C737_0 N737_0 0 1.02e-12
R737_1h N737_0 N738_0 0.04928
R737_1v N737_0 N837_0 0.051392
C738_0 N738_0 0 1.82e-12
R738_1h N738_0 N739_0 0.033792
R738_1v N738_0 N838_0 0.026048
C739_0 N739_0 0 1.14e-12
R739_1v N739_0 N839_0 0.074624
** row: 74
C740_0 N740_0 0 1.33e-12
R740_1h N740_0 N741_0 0.047872
R740_1v N740_0 N840_0 0.02816
C741_0 N741_0 0 1.54e-12
R741_1h N741_0 N742_0 0.055616
R741_1v N741_0 N841_0 0.011968
C742_0 N742_0 0 1.59e-12
R742_1h N742_0 N743_0 0.026048
R742_1v N742_0 N842_0 0.07392
C743_0 N743_0 0 1.01e-12
R743_1h N743_0 N744_0 0.016192
R743_1v N743_0 N843_0 0.054208
C744_0 N744_0 0 1.18e-12
R744_1h N744_0 N745_0 0.04928
R744_1v N744_0 N844_0 0.027456
C745_0 N745_0 0 1.35e-12
R745_1h N745_0 N746_0 0.071808
R745_1v N745_0 N845_0 0.028864
C746_0 N746_0 0 1.43e-12
R746_1h N746_0 N747_0 0.015488
R746_1v N746_0 N846_0 0.011968
C747_0 N747_0 0 1.53e-12
R747_1h N747_0 N748_0 0.016192
R747_1v N747_0 N847_0 0.050688
C748_0 N748_0 0 1.13e-12
R748_1h N748_0 N749_0 0.026752
R748_1v N748_0 N848_0 0.074624
C749_0 N749_0 0 1.51e-12
R749_1v N749_0 N849_0 0.046464
** row: 75
C750_0 N750_0 0 1.1e-12
R750_1h N750_0 N751_0 0.076736
R750_1v N750_0 N850_0 0.035904
C751_0 N751_0 0 1.69e-12
R751_1h N751_0 N752_0 0.064064
R751_1v N751_0 N851_0 0.07392
C752_0 N752_0 0 1.9e-12
R752_1h N752_0 N753_0 0.069696
R752_1v N752_0 N852_0 0.045056
C753_0 N753_0 0 1.69e-12
R753_1h N753_0 N754_0 0.032384
R753_1v N753_0 N853_0 0.012672
C754_0 N754_0 0 1.82e-12
R754_1h N754_0 N755_0 0.009856
R754_1v N754_0 N854_0 0.025344
C755_0 N755_0 0 1.95e-12
R755_1h N755_0 N756_0 0.030272
R755_1v N755_0 N855_0 0.016896
C756_0 N756_0 0 1.87e-12
R756_1h N756_0 N757_0 0.052096
R756_1v N756_0 N856_0 0.047168
C757_0 N757_0 0 1.51e-12
R757_1h N757_0 N758_0 0.023936
R757_1v N757_0 N857_0 0.01408
C758_0 N758_0 0 1.64e-12
R758_1h N758_0 N759_0 0.033792
R758_1v N758_0 N858_0 0.023232
C759_0 N759_0 0 1.93e-12
R759_1v N759_0 N859_0 0.030976
** row: 76
C760_0 N760_0 0 1.26e-12
R760_1h N760_0 N761_0 0.007744
R760_1v N760_0 N860_0 0.03872
C761_0 N761_0 0 1.25e-12
R761_1h N761_0 N762_0 0.073216
R761_1v N761_0 N861_0 0.053504
C762_0 N762_0 0 1.06e-12
R762_1h N762_0 N763_0 0.069696
R762_1v N762_0 N862_0 0.046464
C763_0 N763_0 0 1.47e-12
R763_1h N763_0 N764_0 0.07392
R763_1v N763_0 N863_0 0.025344
C764_0 N764_0 0 1.84e-12
R764_1h N764_0 N765_0 0.009152
R764_1v N764_0 N864_0 0.04928
C765_0 N765_0 0 1.4e-12
R765_1h N765_0 N766_0 0.064768
R765_1v N765_0 N865_0 0.04576
C766_0 N766_0 0 1.73e-12
R766_1h N766_0 N767_0 0.040832
R766_1v N766_0 N866_0 0.07392
C767_0 N767_0 0 1.9e-12
R767_1h N767_0 N768_0 0.01056
R767_1v N767_0 N867_0 0.039424
C768_0 N768_0 0 1.66e-12
R768_1h N768_0 N769_0 0.054208
R768_1v N768_0 N868_0 0.051392
C769_0 N769_0 0 1.04e-12
R769_1v N769_0 N869_0 0.0704
** row: 77
C770_0 N770_0 0 1.08e-12
R770_1h N770_0 N771_0 0.0704
R770_1v N770_0 N870_0 0.054912
C771_0 N771_0 0 1.61e-12
R771_1h N771_0 N772_0 0.03168
R771_1v N771_0 N871_0 0.072512
C772_0 N772_0 0 1.55e-12
R772_1h N772_0 N773_0 0.007744
R772_1v N772_0 N872_0 0.042944
C773_0 N773_0 0 1.44e-12
R773_1h N773_0 N774_0 0.01408
R773_1v N773_0 N873_0 0.042944
C774_0 N774_0 0 1.91e-12
R774_1h N774_0 N775_0 0.068992
R774_1v N774_0 N874_0 0.03168
C775_0 N775_0 0 1.47e-12
R775_1h N775_0 N776_0 0.040832
R775_1v N775_0 N875_0 0.05984
C776_0 N776_0 0 1.81e-12
R776_1h N776_0 N777_0 0.046464
R776_1v N776_0 N876_0 0.00704
C777_0 N777_0 0 1.29e-12
R777_1h N777_0 N778_0 0.042944
R777_1v N777_0 N877_0 0.036608
C778_0 N778_0 0 1.34e-12
R778_1h N778_0 N779_0 0.041536
R778_1v N778_0 N878_0 0.04928
C779_0 N779_0 0 1.01e-12
R779_1v N779_0 N879_0 0.052096
** row: 78
C780_0 N780_0 0 1.64e-12
R780_1h N780_0 N781_0 0.037312
R780_1v N780_0 N880_0 0.057728
C781_0 N781_0 0 1.55e-12
R781_1h N781_0 N782_0 0.014784
R781_1v N781_0 N881_0 0.030272
C782_0 N782_0 0 1.42e-12
R782_1h N782_0 N783_0 0.046464
R782_1v N782_0 N882_0 0.0352
C783_0 N783_0 0 1.96e-12
R783_1h N783_0 N784_0 0.048576
R783_1v N783_0 N883_0 0.032384
C784_0 N784_0 0 1.58e-12
R784_1h N784_0 N785_0 0.01408
R784_1v N784_0 N884_0 0.026752
C785_0 N785_0 0 1.46e-12
R785_1h N785_0 N786_0 0.075328
R785_1v N785_0 N885_0 0.05984
C786_0 N786_0 0 1.94e-12
R786_1h N786_0 N787_0 0.023936
R786_1v N786_0 N886_0 0.046464
C787_0 N787_0 0 1.5e-12
R787_1h N787_0 N788_0 0.02464
R787_1v N787_0 N887_0 0.06688
C788_0 N788_0 0 1.53e-12
R788_1h N788_0 N789_0 0.020416
R788_1v N788_0 N888_0 0.057024
C789_0 N789_0 0 1.55e-12
R789_1v N789_0 N889_0 0.06336
** row: 79
C790_0 N790_0 0 1.24e-12
R790_1h N790_0 N791_0 0.020416
R790_1v N790_0 N890_0 0.074624
C791_0 N791_0 0 1.67e-12
R791_1h N791_0 N792_0 0.038016
R791_1v N791_0 N891_0 0.009152
C792_0 N792_0 0 1.3e-12
R792_1h N792_0 N793_0 0.027456
R792_1v N792_0 N892_0 0.039424
C793_0 N793_0 0 1.86e-12
R793_1h N793_0 N794_0 0.05632
R793_1v N793_0 N893_0 0.073216
C794_0 N794_0 0 1.45e-12
R794_1h N794_0 N795_0 0.047872
R794_1v N794_0 N894_0 0.043648
C795_0 N795_0 0 1.08e-12
R795_1h N795_0 N796_0 0.067584
R795_1v N795_0 N895_0 0.076032
C796_0 N796_0 0 1.05e-12
R796_1h N796_0 N797_0 0.016192
R796_1v N796_0 N896_0 0.038016
C797_0 N797_0 0 1.3e-12
R797_1h N797_0 N798_0 0.021824
R797_1v N797_0 N897_0 0.040128
C798_0 N798_0 0 1.07e-12
R798_1h N798_0 N799_0 0.047872
R798_1v N798_0 N898_0 0.00704
C799_0 N799_0 0 1.78e-12
R799_1v N799_0 N899_0 0.027456
** row: 80
C800_0 N800_0 0 1.07e-12
R800_1h N800_0 N801_0 0.047872
R800_1v N800_0 N900_0 0.044352
C801_0 N801_0 0 1.79e-12
R801_1h N801_0 N802_0 0.011968
R801_1v N801_0 N901_0 0.057728
C802_0 N802_0 0 1.75e-12
R802_1h N802_0 N803_0 0.01408
R802_1v N802_0 N902_0 0.008448
C803_0 N803_0 0 1.04e-12
R803_1h N803_0 N804_0 0.012672
R803_1v N803_0 N903_0 0.0352
C804_0 N804_0 0 1.26e-12
R804_1h N804_0 N805_0 0.008448
R804_1v N804_0 N904_0 0.067584
C805_0 N805_0 0 1.85e-12
R805_1h N805_0 N806_0 0.011264
R805_1v N805_0 N905_0 0.039424
C806_0 N806_0 0 1.23e-12
R806_1h N806_0 N807_0 0.009856
R806_1v N806_0 N906_0 0.042944
C807_0 N807_0 0 1.37e-12
R807_1h N807_0 N808_0 0.007744
R807_1v N807_0 N907_0 0.030272
C808_0 N808_0 0 1.1e-12
R808_1h N808_0 N809_0 0.040832
R808_1v N808_0 N908_0 0.071808
C809_0 N809_0 0 1.69e-12
R809_1v N809_0 N909_0 0.00704
** row: 81
C810_0 N810_0 0 1.71e-12
R810_1h N810_0 N811_0 0.04224
R810_1v N810_0 N910_0 0.012672
C811_0 N811_0 0 1.81e-12
R811_1h N811_0 N812_0 0.046464
R811_1v N811_0 N911_0 0.068288
C812_0 N812_0 0 1.88e-12
R812_1h N812_0 N813_0 0.026752
R812_1v N812_0 N912_0 0.050688
C813_0 N813_0 0 1.51e-12
R813_1h N813_0 N814_0 0.065472
R813_1v N813_0 N913_0 0.019712
C814_0 N814_0 0 1.59e-12
R814_1h N814_0 N815_0 0.023232
R814_1v N814_0 N914_0 0.03872
C815_0 N815_0 0 1.14e-12
R815_1h N815_0 N816_0 0.049984
R815_1v N815_0 N915_0 0.064768
C816_0 N816_0 0 1.72e-12
R816_1h N816_0 N817_0 0.011968
R816_1v N816_0 N916_0 0.047168
C817_0 N817_0 0 1.29e-12
R817_1h N817_0 N818_0 0.014784
R817_1v N817_0 N917_0 0.073216
C818_0 N818_0 0 1.3e-12
R818_1h N818_0 N819_0 0.038016
R818_1v N818_0 N918_0 0.047168
C819_0 N819_0 0 1.78e-12
R819_1v N819_0 N919_0 0.033088
** row: 82
C820_0 N820_0 0 1.26e-12
R820_1h N820_0 N821_0 0.061952
R820_1v N820_0 N920_0 0.04928
C821_0 N821_0 0 1.28e-12
R821_1h N821_0 N822_0 0.067584
R821_1v N821_0 N921_0 0.035904
C822_0 N822_0 0 1.84e-12
R822_1h N822_0 N823_0 0.02464
R822_1v N822_0 N922_0 0.064768
C823_0 N823_0 0 1.65e-12
R823_1h N823_0 N824_0 0.034496
R823_1v N823_0 N923_0 0.030272
C824_0 N824_0 0 1.48e-12
R824_1h N824_0 N825_0 0.047872
R824_1v N824_0 N924_0 0.038016
C825_0 N825_0 0 1.23e-12
R825_1h N825_0 N826_0 0.04576
R825_1v N825_0 N925_0 0.01408
C826_0 N826_0 0 1.85e-12
R826_1h N826_0 N827_0 0.069696
R826_1v N826_0 N926_0 0.065472
C827_0 N827_0 0 1.44e-12
R827_1h N827_0 N828_0 0.039424
R827_1v N827_0 N927_0 0.015488
C828_0 N828_0 0 1.55e-12
R828_1h N828_0 N829_0 0.072512
R828_1v N828_0 N928_0 0.036608
C829_0 N829_0 0 1e-12
R829_1v N829_0 N929_0 0.04224
** row: 83
C830_0 N830_0 0 1.2e-12
R830_1h N830_0 N831_0 0.069696
R830_1v N830_0 N930_0 0.026752
C831_0 N831_0 0 1.5e-12
R831_1h N831_0 N832_0 0.041536
R831_1v N831_0 N931_0 0.046464
C832_0 N832_0 0 1.37e-12
R832_1h N832_0 N833_0 0.036608
R832_1v N832_0 N932_0 0.035904
C833_0 N833_0 0 1.14e-12
R833_1h N833_0 N834_0 0.023936
R833_1v N833_0 N933_0 0.047872
C834_0 N834_0 0 1.54e-12
R834_1h N834_0 N835_0 0.013376
R834_1v N834_0 N934_0 0.047872
C835_0 N835_0 0 1.64e-12
R835_1h N835_0 N836_0 0.045056
R835_1v N835_0 N935_0 0.064064
C836_0 N836_0 0 1.19e-12
R836_1h N836_0 N837_0 0.018304
R836_1v N836_0 N936_0 0.019712
C837_0 N837_0 0 1.6e-12
R837_1h N837_0 N838_0 0.076736
R837_1v N837_0 N937_0 0.051392
C838_0 N838_0 0 1.06e-12
R838_1h N838_0 N839_0 0.051392
R838_1v N838_0 N938_0 0.019712
C839_0 N839_0 0 1.99e-12
R839_1v N839_0 N939_0 0.01056
** row: 84
C840_0 N840_0 0 1.7e-12
R840_1h N840_0 N841_0 0.007744
R840_1v N840_0 N940_0 0.061248
C841_0 N841_0 0 1.11e-12
R841_1h N841_0 N842_0 0.027456
R841_1v N841_0 N941_0 0.026752
C842_0 N842_0 0 1.12e-12
R842_1h N842_0 N843_0 0.067584
R842_1v N842_0 N942_0 0.019008
C843_0 N843_0 0 1.55e-12
R843_1h N843_0 N844_0 0.062656
R843_1v N843_0 N943_0 0.065472
C844_0 N844_0 0 1.79e-12
R844_1h N844_0 N845_0 0.069696
R844_1v N844_0 N944_0 0.033088
C845_0 N845_0 0 1.89e-12
R845_1h N845_0 N846_0 0.040128
R845_1v N845_0 N945_0 0.044352
C846_0 N846_0 0 1.95e-12
R846_1h N846_0 N847_0 0.06336
R846_1v N846_0 N946_0 0.023936
C847_0 N847_0 0 1.11e-12
R847_1h N847_0 N848_0 0.076736
R847_1v N847_0 N947_0 0.066176
C848_0 N848_0 0 1.11e-12
R848_1h N848_0 N849_0 0.016896
R848_1v N848_0 N948_0 0.037312
C849_0 N849_0 0 1.26e-12
R849_1v N849_0 N949_0 0.066176
** row: 85
C850_0 N850_0 0 1.42e-12
R850_1h N850_0 N851_0 0.029568
R850_1v N850_0 N950_0 0.011968
C851_0 N851_0 0 1.96e-12
R851_1h N851_0 N852_0 0.049984
R851_1v N851_0 N951_0 0.019712
C852_0 N852_0 0 1.25e-12
R852_1h N852_0 N853_0 0.035904
R852_1v N852_0 N952_0 0.028864
C853_0 N853_0 0 1.63e-12
R853_1h N853_0 N854_0 0.01408
R853_1v N853_0 N953_0 0.067584
C854_0 N854_0 0 1.94e-12
R854_1h N854_0 N855_0 0.073216
R854_1v N854_0 N954_0 0.019008
C855_0 N855_0 0 1.35e-12
R855_1h N855_0 N856_0 0.065472
R855_1v N855_0 N955_0 0.047872
C856_0 N856_0 0 1.82e-12
R856_1h N856_0 N857_0 0.033088
R856_1v N856_0 N956_0 0.044352
C857_0 N857_0 0 1.15e-12
R857_1h N857_0 N858_0 0.016192
R857_1v N857_0 N957_0 0.019008
C858_0 N858_0 0 1.14e-12
R858_1h N858_0 N859_0 0.076032
R858_1v N858_0 N958_0 0.06336
C859_0 N859_0 0 1.8e-12
R859_1v N859_0 N959_0 0.035904
** row: 86
C860_0 N860_0 0 1.06e-12
R860_1h N860_0 N861_0 0.052096
R860_1v N860_0 N960_0 0.03168
C861_0 N861_0 0 1.38e-12
R861_1h N861_0 N862_0 0.023232
R861_1v N861_0 N961_0 0.028864
C862_0 N862_0 0 1.52e-12
R862_1h N862_0 N863_0 0.036608
R862_1v N862_0 N962_0 0.013376
C863_0 N863_0 0 1.45e-12
R863_1h N863_0 N864_0 0.02464
R863_1v N863_0 N963_0 0.023936
C864_0 N864_0 0 1.56e-12
R864_1h N864_0 N865_0 0.051392
R864_1v N864_0 N964_0 0.057024
C865_0 N865_0 0 1.02e-12
R865_1h N865_0 N866_0 0.06336
R865_1v N865_0 N965_0 0.011264
C866_0 N866_0 0 1.85e-12
R866_1h N866_0 N867_0 0.071104
R866_1v N866_0 N966_0 0.069696
C867_0 N867_0 0 1.74e-12
R867_1h N867_0 N868_0 0.038016
R867_1v N867_0 N967_0 0.046464
C868_0 N868_0 0 1.88e-12
R868_1h N868_0 N869_0 0.049984
R868_1v N868_0 N968_0 0.05632
C869_0 N869_0 0 1.38e-12
R869_1v N869_0 N969_0 0.035904
** row: 87
C870_0 N870_0 0 1.02e-12
R870_1h N870_0 N871_0 0.062656
R870_1v N870_0 N970_0 0.040832
C871_0 N871_0 0 1.18e-12
R871_1h N871_0 N872_0 0.053504
R871_1v N871_0 N971_0 0.033792
C872_0 N872_0 0 1.42e-12
R872_1h N872_0 N873_0 0.04224
R872_1v N872_0 N972_0 0.036608
C873_0 N873_0 0 1.84e-12
R873_1h N873_0 N874_0 0.048576
R873_1v N873_0 N973_0 0.068992
C874_0 N874_0 0 1.61e-12
R874_1h N874_0 N875_0 0.03168
R874_1v N874_0 N974_0 0.074624
C875_0 N875_0 0 1.24e-12
R875_1h N875_0 N876_0 0.011264
R875_1v N875_0 N975_0 0.076032
C876_0 N876_0 0 1.56e-12
R876_1h N876_0 N877_0 0.016192
R876_1v N876_0 N976_0 0.03168
C877_0 N877_0 0 1.47e-12
R877_1h N877_0 N878_0 0.045056
R877_1v N877_0 N977_0 0.050688
C878_0 N878_0 0 1.44e-12
R878_1h N878_0 N879_0 0.01408
R878_1v N878_0 N978_0 0.008448
C879_0 N879_0 0 1.57e-12
R879_1v N879_0 N979_0 0.029568
** row: 88
C880_0 N880_0 0 1.4e-12
R880_1h N880_0 N881_0 0.042944
R880_1v N880_0 N980_0 0.067584
C881_0 N881_0 0 1.71e-12
R881_1h N881_0 N882_0 0.076736
R881_1v N881_0 N981_0 0.009856
C882_0 N882_0 0 1.89e-12
R882_1h N882_0 N883_0 0.069696
R882_1v N882_0 N982_0 0.039424
C883_0 N883_0 0 1.39e-12
R883_1h N883_0 N884_0 0.066176
R883_1v N883_0 N983_0 0.064768
C884_0 N884_0 0 1.5e-12
R884_1h N884_0 N885_0 0.057728
R884_1v N884_0 N984_0 0.037312
C885_0 N885_0 0 1.86e-12
R885_1h N885_0 N886_0 0.054912
R885_1v N885_0 N985_0 0.020416
C886_0 N886_0 0 1.92e-12
R886_1h N886_0 N887_0 0.019712
R886_1v N886_0 N986_0 0.060544
C887_0 N887_0 0 1.57e-12
R887_1h N887_0 N888_0 0.044352
R887_1v N887_0 N987_0 0.05984
C888_0 N888_0 0 1.63e-12
R888_1h N888_0 N889_0 0.0176
R888_1v N888_0 N988_0 0.020416
C889_0 N889_0 0 1.25e-12
R889_1v N889_0 N989_0 0.055616
** row: 89
C890_0 N890_0 0 1.77e-12
R890_1h N890_0 N891_0 0.013376
R890_1v N890_0 N990_0 0.013376
C891_0 N891_0 0 1.8e-12
R891_1h N891_0 N892_0 0.07392
R891_1v N891_0 N991_0 0.029568
C892_0 N892_0 0 1.31e-12
R892_1h N892_0 N893_0 0.00704
R892_1v N892_0 N992_0 0.022528
C893_0 N893_0 0 1.2e-12
R893_1h N893_0 N894_0 0.039424
R893_1v N893_0 N993_0 0.016192
C894_0 N894_0 0 1.56e-12
R894_1h N894_0 N895_0 0.027456
R894_1v N894_0 N994_0 0.052096
C895_0 N895_0 0 1.28e-12
R895_1h N895_0 N896_0 0.023936
R895_1v N895_0 N995_0 0.04224
C896_0 N896_0 0 1.48e-12
R896_1h N896_0 N897_0 0.038016
R896_1v N896_0 N996_0 0.073216
C897_0 N897_0 0 1.18e-12
R897_1h N897_0 N898_0 0.057728
R897_1v N897_0 N997_0 0.009856
C898_0 N898_0 0 1.72e-12
R898_1h N898_0 N899_0 0.040128
R898_1v N898_0 N998_0 0.054208
C899_0 N899_0 0 1.39e-12
R899_1v N899_0 N999_0 0.020416
** row: 90
C900_0 N900_0 0 1.93e-12
R900_1h N900_0 N901_0 0.013376
R900_1v N900_0 N1000_0 0.040832
C901_0 N901_0 0 1.54e-12
R901_1h N901_0 N902_0 0.05632
R901_1v N901_0 N1001_0 0.026752
C902_0 N902_0 0 1.5e-12
R902_1h N902_0 N903_0 0.04576
R902_1v N902_0 N1002_0 0.048576
C903_0 N903_0 0 1.5e-12
R903_1h N903_0 N904_0 0.027456
R903_1v N903_0 N1003_0 0.028864
C904_0 N904_0 0 1.48e-12
R904_1h N904_0 N905_0 0.036608
R904_1v N904_0 N1004_0 0.068992
C905_0 N905_0 0 1.77e-12
R905_1h N905_0 N906_0 0.011264
R905_1v N905_0 N1005_0 0.054912
C906_0 N906_0 0 1.54e-12
R906_1h N906_0 N907_0 0.012672
R906_1v N906_0 N1006_0 0.055616
C907_0 N907_0 0 1.98e-12
R907_1h N907_0 N908_0 0.009152
R907_1v N907_0 N1007_0 0.068288
C908_0 N908_0 0 1.7e-12
R908_1h N908_0 N909_0 0.011968
R908_1v N908_0 N1008_0 0.014784
C909_0 N909_0 0 1.69e-12
R909_1v N909_0 N1009_0 0.025344
** row: 91
C910_0 N910_0 0 1.03e-12
R910_1h N910_0 N911_0 0.0352
R910_1v N910_0 N1010_0 0.057024
C911_0 N911_0 0 1.64e-12
R911_1h N911_0 N912_0 0.068992
R911_1v N911_0 N1011_0 0.025344
C912_0 N912_0 0 1.86e-12
R912_1h N912_0 N913_0 0.018304
R912_1v N912_0 N1012_0 0.060544
C913_0 N913_0 0 1.41e-12
R913_1h N913_0 N914_0 0.026048
R913_1v N913_0 N1013_0 0.061952
C914_0 N914_0 0 1.22e-12
R914_1h N914_0 N915_0 0.048576
R914_1v N914_0 N1014_0 0.025344
C915_0 N915_0 0 1.65e-12
R915_1h N915_0 N916_0 0.076736
R915_1v N915_0 N1015_0 0.009856
C916_0 N916_0 0 1.23e-12
R916_1h N916_0 N917_0 0.054208
R916_1v N916_0 N1016_0 0.047872
C917_0 N917_0 0 1.32e-12
R917_1h N917_0 N918_0 0.068992
R917_1v N917_0 N1017_0 0.012672
C918_0 N918_0 0 1.87e-12
R918_1h N918_0 N919_0 0.060544
R918_1v N918_0 N1018_0 0.02816
C919_0 N919_0 0 1.94e-12
R919_1v N919_0 N1019_0 0.034496
** row: 92
C920_0 N920_0 0 1.51e-12
R920_1h N920_0 N921_0 0.057728
R920_1v N920_0 N1020_0 0.036608
C921_0 N921_0 0 1.92e-12
R921_1h N921_0 N922_0 0.038016
R921_1v N921_0 N1021_0 0.011264
C922_0 N922_0 0 1.8e-12
R922_1h N922_0 N923_0 0.022528
R922_1v N922_0 N1022_0 0.072512
C923_0 N923_0 0 1.49e-12
R923_1h N923_0 N924_0 0.076032
R923_1v N923_0 N1023_0 0.067584
C924_0 N924_0 0 1.28e-12
R924_1h N924_0 N925_0 0.060544
R924_1v N924_0 N1024_0 0.013376
C925_0 N925_0 0 1.87e-12
R925_1h N925_0 N926_0 0.008448
R925_1v N925_0 N1025_0 0.025344
C926_0 N926_0 0 1.38e-12
R926_1h N926_0 N927_0 0.047872
R926_1v N926_0 N1026_0 0.041536
C927_0 N927_0 0 1.58e-12
R927_1h N927_0 N928_0 0.054912
R927_1v N927_0 N1027_0 0.064064
C928_0 N928_0 0 1.46e-12
R928_1h N928_0 N929_0 0.026752
R928_1v N928_0 N1028_0 0.02112
C929_0 N929_0 0 1.74e-12
R929_1v N929_0 N1029_0 0.047872
** row: 93
C930_0 N930_0 0 1.14e-12
R930_1h N930_0 N931_0 0.016896
R930_1v N930_0 N1030_0 0.050688
C931_0 N931_0 0 1.39e-12
R931_1h N931_0 N932_0 0.046464
R931_1v N931_0 N1031_0 0.045056
C932_0 N932_0 0 1.35e-12
R932_1h N932_0 N933_0 0.0176
R932_1v N932_0 N1032_0 0.030976
C933_0 N933_0 0 1.57e-12
R933_1h N933_0 N934_0 0.04928
R933_1v N933_0 N1033_0 0.03168
C934_0 N934_0 0 1.07e-12
R934_1h N934_0 N935_0 0.039424
R934_1v N934_0 N1034_0 0.052096
C935_0 N935_0 0 1.83e-12
R935_1h N935_0 N936_0 0.04576
R935_1v N935_0 N1035_0 0.009152
C936_0 N936_0 0 1.37e-12
R936_1h N936_0 N937_0 0.030272
R936_1v N936_0 N1036_0 0.036608
C937_0 N937_0 0 1.48e-12
R937_1h N937_0 N938_0 0.065472
R937_1v N937_0 N1037_0 0.00704
C938_0 N938_0 0 1.68e-12
R938_1h N938_0 N939_0 0.018304
R938_1v N938_0 N1038_0 0.039424
C939_0 N939_0 0 1.49e-12
R939_1v N939_0 N1039_0 0.033088
** row: 94
C940_0 N940_0 0 1.21e-12
R940_1h N940_0 N941_0 0.048576
R940_1v N940_0 N1040_0 0.009152
C941_0 N941_0 0 1.87e-12
R941_1h N941_0 N942_0 0.021824
R941_1v N941_0 N1041_0 0.036608
C942_0 N942_0 0 1.43e-12
R942_1h N942_0 N943_0 0.05984
R942_1v N942_0 N1042_0 0.061248
C943_0 N943_0 0 1.1e-12
R943_1h N943_0 N944_0 0.050688
R943_1v N943_0 N1043_0 0.067584
C944_0 N944_0 0 1.7e-12
R944_1h N944_0 N945_0 0.075328
R944_1v N944_0 N1044_0 0.072512
C945_0 N945_0 0 1.17e-12
R945_1h N945_0 N946_0 0.049984
R945_1v N945_0 N1045_0 0.026752
C946_0 N946_0 0 1.24e-12
R946_1h N946_0 N947_0 0.019008
R946_1v N946_0 N1046_0 0.053504
C947_0 N947_0 0 1.58e-12
R947_1h N947_0 N948_0 0.048576
R947_1v N947_0 N1047_0 0.053504
C948_0 N948_0 0 1.93e-12
R948_1h N948_0 N949_0 0.048576
R948_1v N948_0 N1048_0 0.067584
C949_0 N949_0 0 1.09e-12
R949_1v N949_0 N1049_0 0.047168
** row: 95
C950_0 N950_0 0 1.35e-12
R950_1h N950_0 N951_0 0.039424
R950_1v N950_0 N1050_0 0.02816
C951_0 N951_0 0 1.95e-12
R951_1h N951_0 N952_0 0.008448
R951_1v N951_0 N1051_0 0.019008
C952_0 N952_0 0 1.16e-12
R952_1h N952_0 N953_0 0.074624
R952_1v N952_0 N1052_0 0.016192
C953_0 N953_0 0 1.92e-12
R953_1h N953_0 N954_0 0.059136
R953_1v N953_0 N1053_0 0.023232
C954_0 N954_0 0 1.06e-12
R954_1h N954_0 N955_0 0.04928
R954_1v N954_0 N1054_0 0.073216
C955_0 N955_0 0 1.03e-12
R955_1h N955_0 N956_0 0.011264
R955_1v N955_0 N1055_0 0.051392
C956_0 N956_0 0 1.17e-12
R956_1h N956_0 N957_0 0.030976
R956_1v N956_0 N1056_0 0.034496
C957_0 N957_0 0 1.34e-12
R957_1h N957_0 N958_0 0.043648
R957_1v N957_0 N1057_0 0.041536
C958_0 N958_0 0 1.93e-12
R958_1h N958_0 N959_0 0.019712
R958_1v N958_0 N1058_0 0.036608
C959_0 N959_0 0 1.04e-12
R959_1v N959_0 N1059_0 0.01056
** row: 96
C960_0 N960_0 0 1.04e-12
R960_1h N960_0 N961_0 0.016192
R960_1v N960_0 N1060_0 0.071808
C961_0 N961_0 0 1.02e-12
R961_1h N961_0 N962_0 0.038016
R961_1v N961_0 N1061_0 0.068288
C962_0 N962_0 0 1.04e-12
R962_1h N962_0 N963_0 0.049984
R962_1v N962_0 N1062_0 0.046464
C963_0 N963_0 0 1.01e-12
R963_1h N963_0 N964_0 0.025344
R963_1v N963_0 N1063_0 0.040832
C964_0 N964_0 0 1.27e-12
R964_1h N964_0 N965_0 0.04224
R964_1v N964_0 N1064_0 0.045056
C965_0 N965_0 0 1.39e-12
R965_1h N965_0 N966_0 0.074624
R965_1v N965_0 N1065_0 0.013376
C966_0 N966_0 0 1.45e-12
R966_1h N966_0 N967_0 0.014784
R966_1v N966_0 N1066_0 0.025344
C967_0 N967_0 0 1.8e-12
R967_1h N967_0 N968_0 0.008448
R967_1v N967_0 N1067_0 0.015488
C968_0 N968_0 0 1.32e-12
R968_1h N968_0 N969_0 0.043648
R968_1v N968_0 N1068_0 0.047168
C969_0 N969_0 0 1.03e-12
R969_1v N969_0 N1069_0 0.039424
** row: 97
C970_0 N970_0 0 1.61e-12
R970_1h N970_0 N971_0 0.04928
R970_1v N970_0 N1070_0 0.04224
C971_0 N971_0 0 1.27e-12
R971_1h N971_0 N972_0 0.043648
R971_1v N971_0 N1071_0 0.044352
C972_0 N972_0 0 1.71e-12
R972_1h N972_0 N973_0 0.0352
R972_1v N972_0 N1072_0 0.047168
C973_0 N973_0 0 1.84e-12
R973_1h N973_0 N974_0 0.040832
R973_1v N973_0 N1073_0 0.01408
C974_0 N974_0 0 1.11e-12
R974_1h N974_0 N975_0 0.040832
R974_1v N974_0 N1074_0 0.033088
C975_0 N975_0 0 1.13e-12
R975_1h N975_0 N976_0 0.045056
R975_1v N975_0 N1075_0 0.061248
C976_0 N976_0 0 1.61e-12
R976_1h N976_0 N977_0 0.051392
R976_1v N976_0 N1076_0 0.059136
C977_0 N977_0 0 1.24e-12
R977_1h N977_0 N978_0 0.036608
R977_1v N977_0 N1077_0 0.045056
C978_0 N978_0 0 1.26e-12
R978_1h N978_0 N979_0 0.045056
R978_1v N978_0 N1078_0 0.034496
C979_0 N979_0 0 1.78e-12
R979_1v N979_0 N1079_0 0.052096
** row: 98
C980_0 N980_0 0 1.42e-12
R980_1h N980_0 N981_0 0.02464
R980_1v N980_0 N1080_0 0.061248
C981_0 N981_0 0 1.02e-12
R981_1h N981_0 N982_0 0.026048
R981_1v N981_0 N1081_0 0.009856
C982_0 N982_0 0 1.54e-12
R982_1h N982_0 N983_0 0.06336
R982_1v N982_0 N1082_0 0.05984
C983_0 N983_0 0 1.46e-12
R983_1h N983_0 N984_0 0.0704
R983_1v N983_0 N1083_0 0.04928
C984_0 N984_0 0 1.94e-12
R984_1h N984_0 N985_0 0.00704
R984_1v N984_0 N1084_0 0.023232
C985_0 N985_0 0 1.42e-12
R985_1h N985_0 N986_0 0.0704
R985_1v N985_0 N1085_0 0.068992
C986_0 N986_0 0 1.96e-12
R986_1h N986_0 N987_0 0.020416
R986_1v N986_0 N1086_0 0.041536
C987_0 N987_0 0 1.12e-12
R987_1h N987_0 N988_0 0.072512
R987_1v N987_0 N1087_0 0.02464
C988_0 N988_0 0 1.54e-12
R988_1h N988_0 N989_0 0.040832
R988_1v N988_0 N1088_0 0.042944
C989_0 N989_0 0 1.6e-12
R989_1v N989_0 N1089_0 0.068288
** row: 99
C990_0 N990_0 0 1.82e-12
R990_1h N990_0 N991_0 0.023936
C991_0 N991_0 0 1.29e-12
R991_1h N991_0 N992_0 0.048576
C992_0 N992_0 0 1.02e-12
R992_1h N992_0 N993_0 0.065472
C993_0 N993_0 0 1.86e-12
R993_1h N993_0 N994_0 0.011264
C994_0 N994_0 0 1.37e-12
R994_1h N994_0 N995_0 0.054208
C995_0 N995_0 0 1.34e-12
R995_1h N995_0 N996_0 0.032384
C996_0 N996_0 0 1.09e-12
R996_1h N996_0 N997_0 0.039424
C997_0 N997_0 0 1.3e-12
R997_1h N997_0 N998_0 0.013376
C998_0 N998_0 0 1.69e-12
R998_1h N998_0 N999_0 0.02464
C999_0 N999_0 0 1.51e-12

* current sources
I1 0 N1_0 PWL(0 0
+ 22ns 0.00219
+ 37ns 0.0049
+ 52ns 0.00232
+ 67ns 0.00102
+ 82ns 0.00512
+ 97ns 0.00996
+ 112ns 0.001287
+ 127ns 0.006464
+ 142ns 0.005332
+ 157ns 0.00208
+ 172ns 3e-06
+ 187ns 0
+ )
I10 0 N10_0 PWL(0 0
+ 21ns 0.00096
+ 36ns 0.00189
+ 51ns 0.0012
+ 66ns 0.000804
+ 81ns 0.00528
+ 96ns 0.00444
+ 111ns 0.000132
+ 126ns 0.003333
+ 141ns 0.004402
+ 156ns 0.00368
+ 171ns 9.4e-05
+ 186ns 0
+ )
I20 0 N20_0 PWL(0 0
+ 40ns 0.00165
+ 55ns 0.00266
+ 70ns 0
+ 85ns 8.4e-05
+ 100ns 0.00376
+ 115ns 0.00876
+ 130ns 0.002541
+ 145ns 0.005757
+ 160ns 0.003658
+ 175ns 0.00372
+ 190ns 9.2e-05
+ 205ns 0
+ )
I30 0 N30_0 PWL(0 0
+ 42ns 0.00234
+ 57ns 0.00014
+ 72ns 0.0024
+ 87ns 0.000564
+ 102ns 0.00248
+ 117ns 0.00528
+ 132ns 0.000858
+ 147ns 0.006161
+ 162ns 0.000682
+ 177ns 0.00368
+ 192ns 9.8e-05
+ 207ns 0
+ )
I40 0 N40_0 PWL(0 0
+ 32ns 0.00063
+ 47ns 0.0042
+ 62ns 0.00284
+ 77ns 0.00108
+ 92ns 0.00696
+ 107ns 0.00948
+ 122ns 0.00264
+ 137ns 0.008787
+ 152ns 0.005332
+ 167ns 0.00316
+ 182ns 1.3e-05
+ 197ns 0
+ )
I50 0 N50_0 PWL(0 0
+ 31ns 0.00072
+ 46ns 0.00063
+ 61ns 0.00112
+ 76ns 0.000888
+ 91ns 0.00528
+ 106ns 0.00708
+ 121ns 0.000957
+ 136ns 0.002727
+ 151ns 0.003596
+ 166ns 0.0024
+ 181ns 7.1e-05
+ 196ns 0
+ )
I60 0 N60_0 PWL(0 0
+ 18ns 0.00105
+ 33ns 0.00203
+ 48ns 0.00096
+ 63ns 3.6e-05
+ 78ns 0.00464
+ 93ns 0.0054
+ 108ns 0.000495
+ 123ns 0.008282
+ 138ns 0.005456
+ 153ns 0.00012
+ 168ns 6.1e-05
+ 183ns 0
+ )
I70 0 N70_0 PWL(0 0
+ 17ns 0.00141
+ 32ns 0
+ 47ns 0.0022
+ 62ns 0.000744
+ 77ns 0.00288
+ 92ns 0.00372
+ 107ns 0.002343
+ 122ns 0.001717
+ 137ns 0.003596
+ 152ns 0.00152
+ 167ns 7.6e-05
+ 182ns 0
+ )
I80 0 N80_0 PWL(0 0
+ 22ns 0.00102
+ 37ns 0.00693
+ 52ns 0.0016
+ 67ns 0.00084
+ 82ns 0.00576
+ 97ns 0.00324
+ 112ns 0.001683
+ 127ns 0.009696
+ 142ns 0.005084
+ 157ns 0.0004
+ 172ns 9.4e-05
+ 187ns 0
+ )
I90 0 N90_0 PWL(0 0
+ 37ns 0.00246
+ 52ns 0.00371
+ 67ns 0.00212
+ 82ns 2.4e-05
+ 97ns 0.00376
+ 112ns 0.00624
+ 127ns 0.001782
+ 142ns 0.005555
+ 157ns 0.000868
+ 172ns 0.00364
+ 187ns 8.6e-05
+ 202ns 0
+ )
I100 0 N100_0 PWL(0 0
+ 25ns 0.00132
+ 40ns 0.00196
+ 55ns 0.00352
+ 70ns 0.000996
+ 85ns 0.0036
+ 100ns 0.00264
+ 115ns 0.001122
+ 130ns 0.003737
+ 145ns 0.002728
+ 160ns 0.00028
+ 175ns 6.5e-05
+ 190ns 0
+ )
I110 0 N110_0 PWL(0 0
+ 30ns 0.00141
+ 45ns 0.00042
+ 60ns 0.00196
+ 75ns 0.001164
+ 90ns 0.004
+ 105ns 0.00996
+ 120ns 6.6e-05
+ 135ns 0.000303
+ 150ns 0.002356
+ 165ns 0.002
+ 180ns 5.5e-05
+ 195ns 0
+ )
I120 0 N120_0 PWL(0 0
+ 40ns 0.00063
+ 55ns 0.00245
+ 70ns 0.00364
+ 85ns 0.000132
+ 100ns 0.0076
+ 115ns 0.01056
+ 130ns 0.001287
+ 145ns 0.008383
+ 160ns 0.001426
+ 175ns 0.00144
+ 190ns 5.7e-05
+ 205ns 0
+ )
I130 0 N130_0 PWL(0 0
+ 31ns 6e-05
+ 46ns 0.00455
+ 61ns 0.00364
+ 76ns 0.0006
+ 91ns 0.0016
+ 106ns 0.0108
+ 121ns 0.000264
+ 136ns 0.002222
+ 151ns 0.005456
+ 166ns 0.00232
+ 181ns 5.7e-05
+ 196ns 0
+ )
I140 0 N140_0 PWL(0 0
+ 26ns 0.00285
+ 41ns 0.0028
+ 56ns 0.00272
+ 71ns 0.00048
+ 86ns 0.00776
+ 101ns 0.00492
+ 116ns 0.002475
+ 131ns 0.004141
+ 146ns 0.003286
+ 161ns 0.00092
+ 176ns 2.9e-05
+ 191ns 0
+ )
I150 0 N150_0 PWL(0 0
+ 23ns 0.00156
+ 38ns 0.00231
+ 53ns 0.00064
+ 68ns 0.00012
+ 83ns 0.00472
+ 98ns 0.0084
+ 113ns 0.000891
+ 128ns 0.00505
+ 143ns 0.004464
+ 158ns 0
+ 173ns 4e-05
+ 188ns 0
+ )
I160 0 N160_0 PWL(0 0
+ 39ns 0.0024
+ 54ns 0.00266
+ 69ns 0.00124
+ 84ns 0.000852
+ 99ns 0.00792
+ 114ns 0.00948
+ 129ns 0.002079
+ 144ns 0.001919
+ 159ns 0.001178
+ 174ns 0.00244
+ 189ns 1.2e-05
+ 204ns 0
+ )
I170 0 N170_0 PWL(0 0
+ 39ns 0.00051
+ 54ns 0.00483
+ 69ns 0.00332
+ 84ns 0.000744
+ 99ns 0.00224
+ 114ns 0.01044
+ 129ns 0.003135
+ 144ns 0.009696
+ 159ns 0.0031
+ 174ns 0.00216
+ 189ns 6.6e-05
+ 204ns 0
+ )
I180 0 N180_0 PWL(0 0
+ 21ns 0.00114
+ 36ns 0.00203
+ 51ns 0.00384
+ 66ns 0.000216
+ 81ns 0.0044
+ 96ns 0.00348
+ 111ns 0.000264
+ 126ns 0.008787
+ 141ns 0
+ 156ns 0.00028
+ 171ns 1.8e-05
+ 186ns 0
+ )
I190 0 N190_0 PWL(0 0
+ 23ns 0.00111
+ 38ns 0.00196
+ 53ns 0.0036
+ 68ns 0.00042
+ 83ns 0.00656
+ 98ns 0.00096
+ 113ns 0.000165
+ 128ns 0.001717
+ 143ns 0.001364
+ 158ns 0.0034
+ 173ns 5.7e-05
+ 188ns 0
+ )
I200 0 N200_0 PWL(0 0
+ 16ns 0.00021
+ 31ns 0.00161
+ 46ns 0.00396
+ 61ns 0.000432
+ 76ns 0.00632
+ 91ns 0.01068
+ 106ns 0.000594
+ 121ns 0.002727
+ 136ns 0.000434
+ 151ns 0.00292
+ 166ns 5.6e-05
+ 181ns 0
+ )
I210 0 N210_0 PWL(0 0
+ 17ns 0.00024
+ 32ns 0.00518
+ 47ns 0.0012
+ 62ns 0.000912
+ 77ns 0.00032
+ 92ns 0.00228
+ 107ns 0.001848
+ 122ns 0.004646
+ 137ns 0.00341
+ 152ns 0.00156
+ 167ns 6e-06
+ 182ns 0
+ )
I220 0 N220_0 PWL(0 0
+ 33ns 0.00084
+ 48ns 0.00679
+ 63ns 0.0026
+ 78ns 0.001164
+ 93ns 0.0024
+ 108ns 0.00864
+ 123ns 0.002376
+ 138ns 0.002929
+ 153ns 0.003782
+ 168ns 0.00012
+ 183ns 1.8e-05
+ 198ns 0
+ )
I230 0 N230_0 PWL(0 0
+ 38ns 0.00231
+ 53ns 0.00392
+ 68ns 0.00364
+ 83ns 0.000528
+ 98ns 0.00552
+ 113ns 0.00624
+ 128ns 0.00231
+ 143ns 0.005151
+ 158ns 0.001736
+ 173ns 0.00104
+ 188ns 2.3e-05
+ 203ns 0
+ )
I240 0 N240_0 PWL(0 0
+ 37ns 0.0009
+ 52ns 0.00525
+ 67ns 0.00316
+ 82ns 0.001128
+ 97ns 0.00672
+ 112ns 0.00708
+ 127ns 0.003003
+ 142ns 0.004949
+ 157ns 0.000558
+ 172ns 0.00292
+ 187ns 7.4e-05
+ 202ns 0
+ )
I250 0 N250_0 PWL(0 0
+ 17ns 0.00105
+ 32ns 0.00259
+ 47ns 0.00288
+ 62ns 0.000792
+ 77ns 0.0016
+ 92ns 0.00012
+ 107ns 0.002442
+ 122ns 0.001111
+ 137ns 0.00279
+ 152ns 0.00172
+ 167ns 1.5e-05
+ 182ns 0
+ )
I260 0 N260_0 PWL(0 0
+ 42ns 0.00129
+ 57ns 0.00651
+ 72ns 0.00088
+ 87ns 0.00096
+ 102ns 0.00136
+ 117ns 0.00048
+ 132ns 0.000231
+ 147ns 0.009696
+ 162ns 0.006076
+ 177ns 0.00364
+ 192ns 8e-06
+ 207ns 0
+ )
I270 0 N270_0 PWL(0 0
+ 18ns 0.00051
+ 33ns 0.00434
+ 48ns 0.00268
+ 63ns 0.0006
+ 78ns 0.00128
+ 93ns 0.00648
+ 108ns 0.002871
+ 123ns 0.00404
+ 138ns 0.004464
+ 153ns 0.00236
+ 168ns 4.1e-05
+ 183ns 0
+ )
I280 0 N280_0 PWL(0 0
+ 38ns 0.00114
+ 53ns 0.00294
+ 68ns 0.00152
+ 83ns 6e-05
+ 98ns 0.00712
+ 113ns 0.00984
+ 128ns 0.00165
+ 143ns 0.006363
+ 158ns 0.000868
+ 173ns 0.00268
+ 188ns 6.7e-05
+ 203ns 0
+ )
I290 0 N290_0 PWL(0 0
+ 41ns 0.00195
+ 56ns 0.00455
+ 71ns 0.00096
+ 86ns 7.2e-05
+ 101ns 0.00464
+ 116ns 0.00492
+ 131ns 0.00066
+ 146ns 0.002525
+ 161ns 0.005642
+ 176ns 0.00352
+ 191ns 7.9e-05
+ 206ns 0
+ )
I300 0 N300_0 PWL(0 0
+ 33ns 0.00153
+ 48ns 0.0063
+ 63ns 0.00276
+ 78ns 0.001164
+ 93ns 0.00104
+ 108ns 0.00708
+ 123ns 0.003003
+ 138ns 0.005252
+ 153ns 0.000992
+ 168ns 0.00128
+ 183ns 8.6e-05
+ 198ns 0
+ )
I310 0 N310_0 PWL(0 0
+ 40ns 0
+ 55ns 0.00595
+ 70ns 0.00056
+ 85ns 0.000876
+ 100ns 8e-05
+ 115ns 0.00948
+ 130ns 0.001254
+ 145ns 0.007777
+ 160ns 0.002294
+ 175ns 0.00384
+ 190ns 1.8e-05
+ 205ns 0
+ )
I320 0 N320_0 PWL(0 0
+ 38ns 0.00186
+ 53ns 0.00315
+ 68ns 0.00016
+ 83ns 0.001116
+ 98ns 0.002
+ 113ns 0.00084
+ 128ns 0.001155
+ 143ns 0.004646
+ 158ns 0.00031
+ 173ns 0.00196
+ 188ns 5e-06
+ 203ns 0
+ )
I330 0 N330_0 PWL(0 0
+ 28ns 0.00219
+ 43ns 0.00567
+ 58ns 0.00156
+ 73ns 0.000468
+ 88ns 0.00608
+ 103ns 0.01092
+ 118ns 0.002541
+ 133ns 0.009191
+ 148ns 0.003968
+ 163ns 0.0012
+ 178ns 2.2e-05
+ 193ns 0
+ )
I340 0 N340_0 PWL(0 0
+ 23ns 0.0018
+ 38ns 0.00357
+ 53ns 0.00104
+ 68ns 0.000828
+ 83ns 0.00616
+ 98ns 0.0048
+ 113ns 0.000495
+ 128ns 0.008181
+ 143ns 0.002046
+ 158ns 0.00368
+ 173ns 8.9e-05
+ 188ns 0
+ )
I350 0 N350_0 PWL(0 0
+ 34ns 0.00138
+ 49ns 0.0049
+ 64ns 0.00384
+ 79ns 0.001128
+ 94ns 0.00184
+ 109ns 0.0084
+ 124ns 0.002475
+ 139ns 0.001414
+ 154ns 0.003782
+ 169ns 0.00016
+ 184ns 5e-06
+ 199ns 0
+ )
I360 0 N360_0 PWL(0 0
+ 30ns 0.00063
+ 45ns 0.00483
+ 60ns 0.00276
+ 75ns 0.000912
+ 90ns 0.00616
+ 105ns 0.00348
+ 120ns 0.00264
+ 135ns 0.005555
+ 150ns 0.006138
+ 165ns 0.00228
+ 180ns 9.6e-05
+ 195ns 0
+ )
I370 0 N370_0 PWL(0 0
+ 33ns 0.00243
+ 48ns 0.00406
+ 63ns 0.00316
+ 78ns 2.4e-05
+ 93ns 0.00392
+ 108ns 0.003
+ 123ns 0.000792
+ 138ns 0.004646
+ 153ns 0.004464
+ 168ns 0.00188
+ 183ns 1.6e-05
+ 198ns 0
+ )
I380 0 N380_0 PWL(0 0
+ 16ns 0.00231
+ 31ns 0.00357
+ 46ns 0.00072
+ 61ns 0.000192
+ 76ns 0.00784
+ 91ns 0.0048
+ 106ns 0.001221
+ 121ns 0.006868
+ 136ns 0.000992
+ 151ns 0.00264
+ 166ns 4.9e-05
+ 181ns 0
+ )
I390 0 N390_0 PWL(0 0
+ 16ns 0.00144
+ 31ns 0.00035
+ 46ns 0.00276
+ 61ns 0.000792
+ 76ns 0.00768
+ 91ns 0.00612
+ 106ns 0.002541
+ 121ns 0.007575
+ 136ns 0.00031
+ 151ns 0.00104
+ 166ns 5.3e-05
+ 181ns 0
+ )
I400 0 N400_0 PWL(0 0
+ 17ns 0.00075
+ 32ns 0.00203
+ 47ns 0.00352
+ 62ns 0.000864
+ 77ns 0.00344
+ 92ns 0.00216
+ 107ns 0.002508
+ 122ns 0.006161
+ 137ns 0.005332
+ 152ns 0.00104
+ 167ns 1e-06
+ 182ns 0
+ )
I410 0 N410_0 PWL(0 0
+ 19ns 0.0021
+ 34ns 0.00623
+ 49ns 0.00384
+ 64ns 0.000216
+ 79ns 0.00496
+ 94ns 0.01152
+ 109ns 0.000792
+ 124ns 0.003232
+ 139ns 0.003906
+ 154ns 0.0008
+ 169ns 3.5e-05
+ 184ns 0
+ )
I420 0 N420_0 PWL(0 0
+ 22ns 0.00276
+ 37ns 0.00126
+ 52ns 0
+ 67ns 0.000264
+ 82ns 0.00344
+ 97ns 0.003
+ 112ns 0.000132
+ 127ns 0.008383
+ 142ns 0.0031
+ 157ns 0.00188
+ 172ns 1e-06
+ 187ns 0
+ )
I430 0 N430_0 PWL(0 0
+ 43ns 0.00261
+ 58ns 0.00028
+ 73ns 0.00248
+ 88ns 0.000744
+ 103ns 0.00408
+ 118ns 0.00384
+ 133ns 0.001683
+ 148ns 0.004747
+ 163ns 0.000124
+ 178ns 0.00264
+ 193ns 4.3e-05
+ 208ns 0
+ )
I440 0 N440_0 PWL(0 0
+ 25ns 0.00174
+ 40ns 0.00686
+ 55ns 0.00148
+ 70ns 0.0006
+ 85ns 0.00784
+ 100ns 0.00348
+ 115ns 0.002277
+ 130ns 0.009898
+ 145ns 0.000248
+ 160ns 0.00048
+ 175ns 7.6e-05
+ 190ns 0
+ )
I450 0 N450_0 PWL(0 0
+ 42ns 0.00234
+ 57ns 0.00385
+ 72ns 0.00196
+ 87ns 9.6e-05
+ 102ns 0.00504
+ 117ns 0.00432
+ 132ns 0.002112
+ 147ns 0.007777
+ 162ns 0.003162
+ 177ns 0.0006
+ 192ns 9e-06
+ 207ns 0
+ )
I460 0 N460_0 PWL(0 0
+ 19ns 0.00036
+ 34ns 0.0014
+ 49ns 0.0004
+ 64ns 0.00108
+ 79ns 0.0056
+ 94ns 0.00816
+ 109ns 0.001353
+ 124ns 0.000707
+ 139ns 0.004402
+ 154ns 0.00156
+ 169ns 8.9e-05
+ 184ns 0
+ )
I470 0 N470_0 PWL(0 0
+ 34ns 0.00279
+ 49ns 0.00028
+ 64ns 0.00068
+ 79ns 0.000636
+ 94ns 0.00408
+ 109ns 0.00564
+ 124ns 0.000264
+ 139ns 0.005252
+ 154ns 0.00341
+ 169ns 0.00092
+ 184ns 4.1e-05
+ 199ns 0
+ )
I480 0 N480_0 PWL(0 0
+ 36ns 0.00276
+ 51ns 0.00273
+ 66ns 0.00248
+ 81ns 0.000552
+ 96ns 0.00432
+ 111ns 0.00312
+ 126ns 0.000627
+ 141ns 0.001616
+ 156ns 0.004278
+ 171ns 0.00356
+ 186ns 8.4e-05
+ 201ns 0
+ )
I490 0 N490_0 PWL(0 0
+ 34ns 0.00165
+ 49ns 7e-05
+ 64ns 0.0036
+ 79ns 0.000564
+ 94ns 0.00336
+ 109ns 0.00996
+ 124ns 9.9e-05
+ 139ns 0.001212
+ 154ns 0.005456
+ 169ns 0.00028
+ 184ns 1.1e-05
+ 199ns 0
+ )
I500 0 N500_0 PWL(0 0
+ 36ns 0.00057
+ 51ns 0.00497
+ 66ns 0.00208
+ 81ns 0.001092
+ 96ns 0.00192
+ 111ns 0.01152
+ 126ns 0.00099
+ 141ns 0.008787
+ 156ns 0.002666
+ 171ns 0.00144
+ 186ns 6.5e-05
+ 201ns 0
+ )
I510 0 N510_0 PWL(0 0
+ 37ns 0.00102
+ 52ns 0.00021
+ 67ns 0.00356
+ 82ns 0.001152
+ 97ns 0.00032
+ 112ns 0.01152
+ 127ns 0.003201
+ 142ns 0.009494
+ 157ns 0.005952
+ 172ns 0.00368
+ 187ns 2.9e-05
+ 202ns 0
+ )
I520 0 N520_0 PWL(0 0
+ 41ns 0.00051
+ 56ns 0.00406
+ 71ns 0.00268
+ 86ns 0.00078
+ 101ns 0.00176
+ 116ns 0.01032
+ 131ns 0.001221
+ 146ns 0.007474
+ 161ns 0.004774
+ 176ns 0.00244
+ 191ns 7.1e-05
+ 206ns 0
+ )
I530 0 N530_0 PWL(0 0
+ 25ns 0.00198
+ 40ns 0.00672
+ 55ns 0.00264
+ 70ns 0.00096
+ 85ns 0.00392
+ 100ns 0
+ 115ns 0.001155
+ 130ns 0.003838
+ 145ns 0.006014
+ 160ns 0.0016
+ 175ns 3.4e-05
+ 190ns 0
+ )
I540 0 N540_0 PWL(0 0
+ 41ns 0.0009
+ 56ns 0.0063
+ 71ns 0.00064
+ 86ns 0.000984
+ 101ns 0.00368
+ 116ns 0.0102
+ 131ns 0.003036
+ 146ns 0.001414
+ 161ns 0.003162
+ 176ns 0.00056
+ 191ns 5.2e-05
+ 206ns 0
+ )
I550 0 N550_0 PWL(0 0
+ 26ns 0.0009
+ 41ns 0.00371
+ 56ns 0.00256
+ 71ns 0.00108
+ 86ns 0.00432
+ 101ns 0.0036
+ 116ns 0.002838
+ 131ns 0.007272
+ 146ns 0.003844
+ 161ns 0.00348
+ 176ns 7.2e-05
+ 191ns 0
+ )
I560 0 N560_0 PWL(0 0
+ 40ns 0.00063
+ 55ns 0.00623
+ 70ns 0.0024
+ 85ns 0.00024
+ 100ns 0.00608
+ 115ns 0.00504
+ 130ns 0.00033
+ 145ns 0.009292
+ 160ns 0.001488
+ 175ns 0.00036
+ 190ns 2.9e-05
+ 205ns 0
+ )
I570 0 N570_0 PWL(0 0
+ 30ns 0.0024
+ 45ns 0.00581
+ 60ns 0.00108
+ 75ns 0.00024
+ 90ns 0.00192
+ 105ns 0.00108
+ 120ns 0.002442
+ 135ns 0.008888
+ 150ns 0.006138
+ 165ns 0.0032
+ 180ns 7e-05
+ 195ns 0
+ )
I580 0 N580_0 PWL(0 0
+ 17ns 0.00096
+ 32ns 0.00175
+ 47ns 0.00304
+ 62ns 0.000984
+ 77ns 0.00408
+ 92ns 0.01176
+ 107ns 0.002343
+ 122ns 0.006363
+ 137ns 0.00434
+ 152ns 0.00188
+ 167ns 5.7e-05
+ 182ns 0
+ )
I590 0 N590_0 PWL(0 0
+ 26ns 0.00102
+ 41ns 0.00287
+ 56ns 0.00084
+ 71ns 3.6e-05
+ 86ns 0.00128
+ 101ns 0.00636
+ 116ns 0.001254
+ 131ns 0.009696
+ 146ns 0.001612
+ 161ns 0.00252
+ 176ns 5e-06
+ 191ns 0
+ )
I600 0 N600_0 PWL(0 0
+ 38ns 0.00171
+ 53ns 0.00224
+ 68ns 0.00104
+ 83ns 0.00114
+ 98ns 0.00288
+ 113ns 0.00696
+ 128ns 0.00066
+ 143ns 0.001212
+ 158ns 0.005704
+ 173ns 0.00092
+ 188ns 6.2e-05
+ 203ns 0
+ )
I610 0 N610_0 PWL(0 0
+ 23ns 0.00096
+ 38ns 0.00441
+ 53ns 0.00192
+ 68ns 0.00078
+ 83ns 0.00056
+ 98ns 0.00984
+ 113ns 0.001914
+ 128ns 0.002828
+ 143ns 0.002294
+ 158ns 0.00108
+ 173ns 3.3e-05
+ 188ns 0
+ )
I620 0 N620_0 PWL(0 0
+ 38ns 0.00177
+ 53ns 0.0063
+ 68ns 0.00112
+ 83ns 0.000132
+ 98ns 0.00368
+ 113ns 0.0102
+ 128ns 0.003135
+ 143ns 0.007272
+ 158ns 0.001984
+ 173ns 0.00124
+ 188ns 8.2e-05
+ 203ns 0
+ )
I630 0 N630_0 PWL(0 0
+ 21ns 0.00225
+ 36ns 0.00196
+ 51ns 0.00232
+ 66ns 0.000468
+ 81ns 0.00152
+ 96ns 0.00516
+ 111ns 0.001782
+ 126ns 0.006767
+ 141ns 0.00372
+ 156ns 0.00244
+ 171ns 1e-06
+ 186ns 0
+ )
I640 0 N640_0 PWL(0 0
+ 26ns 0.00114
+ 41ns 0.00679
+ 56ns 0.003
+ 71ns 0.000156
+ 86ns 0.0016
+ 101ns 0.01032
+ 116ns 0.001848
+ 131ns 0.000101
+ 146ns 0.006076
+ 161ns 8e-05
+ 176ns 3.8e-05
+ 191ns 0
+ )
I650 0 N650_0 PWL(0 0
+ 19ns 0.00069
+ 34ns 0.00203
+ 49ns 0.00224
+ 64ns 0.000336
+ 79ns 0.002
+ 94ns 0.00372
+ 109ns 0.000264
+ 124ns 0.003535
+ 139ns 0.001364
+ 154ns 0.00316
+ 169ns 3e-05
+ 184ns 0
+ )
I660 0 N660_0 PWL(0 0
+ 21ns 0.0027
+ 36ns 0.0063
+ 51ns 0.00188
+ 66ns 0.000156
+ 81ns 0.00256
+ 96ns 0.00444
+ 111ns 0.00033
+ 126ns 0.000707
+ 141ns 0.003162
+ 156ns 0.00332
+ 171ns 9.3e-05
+ 186ns 0
+ )
I670 0 N670_0 PWL(0 0
+ 41ns 0.00129
+ 56ns 0.00063
+ 71ns 0.00104
+ 86ns 0.001068
+ 101ns 0.0028
+ 116ns 0.00588
+ 131ns 0.000594
+ 146ns 0.009191
+ 161ns 0.004774
+ 176ns 0.0038
+ 191ns 2.3e-05
+ 206ns 0
+ )
I680 0 N680_0 PWL(0 0
+ 35ns 0.00291
+ 50ns 0.00119
+ 65ns 0.00052
+ 80ns 0.000888
+ 95ns 0.00128
+ 110ns 0.0066
+ 125ns 0.002145
+ 140ns 0.001515
+ 155ns 0.004216
+ 170ns 0.00196
+ 185ns 5.3e-05
+ 200ns 0
+ )
I690 0 N690_0 PWL(0 0
+ 31ns 0.00168
+ 46ns 0.00098
+ 61ns 4e-05
+ 76ns 0.00018
+ 91ns 0.004
+ 106ns 0.01164
+ 121ns 0.002508
+ 136ns 0.007676
+ 151ns 0.002356
+ 166ns 0.00044
+ 181ns 2.6e-05
+ 196ns 0
+ )
I700 0 N700_0 PWL(0 0
+ 27ns 0.00165
+ 42ns 0.00021
+ 57ns 0.00308
+ 72ns 0.001116
+ 87ns 0.0068
+ 102ns 0.009
+ 117ns 0.000363
+ 132ns 0.009898
+ 147ns 6.2e-05
+ 162ns 0.00108
+ 177ns 6e-06
+ 192ns 0
+ )
I710 0 N710_0 PWL(0 0
+ 27ns 0.00222
+ 42ns 0.00469
+ 57ns 0.00188
+ 72ns 0.000636
+ 87ns 0.00184
+ 102ns 0.00036
+ 117ns 0.002211
+ 132ns 0.007777
+ 147ns 0.001116
+ 162ns 0.00276
+ 177ns 2.6e-05
+ 192ns 0
+ )
I720 0 N720_0 PWL(0 0
+ 41ns 0.00192
+ 56ns 0.00035
+ 71ns 0.00096
+ 86ns 0.000864
+ 101ns 0.0048
+ 116ns 0.00948
+ 131ns 0.000891
+ 146ns 0.003737
+ 161ns 0.00155
+ 176ns 0.00256
+ 191ns 6.4e-05
+ 206ns 0
+ )
I730 0 N730_0 PWL(0 0
+ 20ns 0.00198
+ 35ns 0.00105
+ 50ns 0.00084
+ 65ns 0.001008
+ 80ns 0.00072
+ 95ns 0.0114
+ 110ns 0.001716
+ 125ns 0.005757
+ 140ns 6.2e-05
+ 155ns 0.00108
+ 170ns 6e-05
+ 185ns 0
+ )
I740 0 N740_0 PWL(0 0
+ 31ns 0.00093
+ 46ns 0.0063
+ 61ns 0.00328
+ 76ns 0.0003
+ 91ns 0.00704
+ 106ns 0.00552
+ 121ns 0.002739
+ 136ns 0.001212
+ 151ns 0.00434
+ 166ns 0.00172
+ 181ns 9.1e-05
+ 196ns 0
+ )
I750 0 N750_0 PWL(0 0
+ 27ns 0.00048
+ 42ns 0.00462
+ 57ns 0.00388
+ 72ns 4.8e-05
+ 87ns 0.00648
+ 102ns 0.00756
+ 117ns 0.002343
+ 132ns 0.005454
+ 147ns 0.006138
+ 162ns 0.00324
+ 177ns 1e-06
+ 192ns 0
+ )
I760 0 N760_0 PWL(0 0
+ 25ns 6e-05
+ 40ns 0.00217
+ 55ns 8e-05
+ 70ns 0.0009
+ 85ns 0.00696
+ 100ns 0.00396
+ 115ns 0.002145
+ 130ns 0.00707
+ 145ns 0.000682
+ 160ns 0.0002
+ 175ns 6.8e-05
+ 190ns 0
+ )
I770 0 N770_0 PWL(0 0
+ 22ns 0.00273
+ 37ns 0.00623
+ 52ns 0.0024
+ 67ns 0.001104
+ 82ns 0.00584
+ 97ns 0.00348
+ 112ns 0.001914
+ 127ns 0.00707
+ 142ns 0.002046
+ 157ns 0.00364
+ 172ns 8.5e-05
+ 187ns 0
+ )
I780 0 N780_0 PWL(0 0
+ 22ns 0.00111
+ 37ns 0.0063
+ 52ns 0.00396
+ 67ns 0.001056
+ 82ns 0.0064
+ 97ns 0.00636
+ 112ns 0.002343
+ 127ns 0.003434
+ 142ns 0.001736
+ 157ns 0.00236
+ 172ns 2e-05
+ 187ns 0
+ )
I790 0 N790_0 PWL(0 0
+ 26ns 0.00249
+ 41ns 0.0035
+ 56ns 4e-05
+ 71ns 0.000348
+ 86ns 0.00152
+ 101ns 0.01104
+ 116ns 0.00231
+ 131ns 0.00808
+ 146ns 0.002294
+ 161ns 0.00172
+ 176ns 9e-06
+ 191ns 0
+ )
I800 0 N800_0 PWL(0 0
+ 41ns 0.00282
+ 56ns 0.00273
+ 71ns 0.00012
+ 86ns 3.6e-05
+ 101ns 0.00704
+ 116ns 0.0048
+ 131ns 0.003069
+ 146ns 0.008787
+ 161ns 0.005022
+ 176ns 0.001
+ 191ns 4.1e-05
+ 206ns 0
+ )
I810 0 N810_0 PWL(0 0
+ 27ns 0.00063
+ 42ns 0.00441
+ 57ns 0.00128
+ 72ns 0.000804
+ 87ns 0.00352
+ 102ns 0.0018
+ 117ns 0.002277
+ 132ns 0.004646
+ 147ns 0.002728
+ 162ns 0.00356
+ 177ns 9e-05
+ 192ns 0
+ )
I820 0 N820_0 PWL(0 0
+ 36ns 0.00081
+ 51ns 0.00063
+ 66ns 0.0012
+ 81ns 0.0009
+ 96ns 0.006
+ 111ns 0.00912
+ 126ns 0.002178
+ 141ns 0.003131
+ 156ns 0.00496
+ 171ns 0.00216
+ 186ns 7.1e-05
+ 201ns 0
+ )
I830 0 N830_0 PWL(0 0
+ 17ns 0.00012
+ 32ns 0.00021
+ 47ns 0.0014
+ 62ns 0.000684
+ 77ns 0.0012
+ 92ns 0.00672
+ 107ns 0.002376
+ 122ns 0.004747
+ 137ns 0.00465
+ 152ns 0.00068
+ 167ns 1.4e-05
+ 182ns 0
+ )
I840 0 N840_0 PWL(0 0
+ 18ns 0.00174
+ 33ns 0.00602
+ 48ns 0.00212
+ 63ns 0.000288
+ 78ns 0.00056
+ 93ns 0.00972
+ 108ns 0.001089
+ 123ns 0.008989
+ 138ns 0.000496
+ 153ns 0.00244
+ 168ns 1.7e-05
+ 183ns 0
+ )
I850 0 N850_0 PWL(0 0
+ 17ns 0.00147
+ 32ns 0.00196
+ 47ns 0.0006
+ 62ns 0.0009
+ 77ns 0.00176
+ 92ns 0.00864
+ 107ns 0.00099
+ 122ns 0.005757
+ 137ns 0.005022
+ 152ns 0.0018
+ 167ns 6.6e-05
+ 182ns 0
+ )
I860 0 N860_0 PWL(0 0
+ 37ns 0.00123
+ 52ns 0.0049
+ 67ns 0.00232
+ 82ns 0.000456
+ 97ns 0.0068
+ 112ns 0.00192
+ 127ns 0.000792
+ 142ns 0.003939
+ 157ns 0.005704
+ 172ns 0.00332
+ 187ns 7.2e-05
+ 202ns 0
+ )
I870 0 N870_0 PWL(0 0
+ 37ns 0.00096
+ 52ns 0.00266
+ 67ns 0.00168
+ 82ns 7.2e-05
+ 97ns 0.00656
+ 112ns 0.01092
+ 127ns 0.002838
+ 142ns 0.00505
+ 157ns 0.001116
+ 172ns 0.00036
+ 187ns 2.2e-05
+ 202ns 0
+ )
I880 0 N880_0 PWL(0 0
+ 33ns 0.00165
+ 48ns 0.00315
+ 63ns 0.00336
+ 78ns 9.6e-05
+ 93ns 0.00712
+ 108ns 0.00936
+ 123ns 0.002607
+ 138ns 0.004747
+ 153ns 0.000992
+ 168ns 0.00256
+ 183ns 1.5e-05
+ 198ns 0
+ )
I890 0 N890_0 PWL(0 0
+ 40ns 0.00021
+ 55ns 0.00532
+ 70ns 0.00316
+ 85ns 0.00102
+ 100ns 8e-05
+ 115ns 0.00132
+ 130ns 0.002475
+ 145ns 0.009595
+ 160ns 0.004278
+ 175ns 0.0004
+ 190ns 8.6e-05
+ 205ns 0
+ )
I901 0 N901_0 PWL(0 0
+ 27ns 0.00171
+ 42ns 0.00119
+ 57ns 0.00344
+ 72ns 0.000684
+ 87ns 0.0028
+ 102ns 0.00492
+ 117ns 9.9e-05
+ 132ns 0.007272
+ 147ns 0.003038
+ 162ns 0.00368
+ 177ns 5e-05
+ 192ns 0
+ )
I910 0 N910_0 PWL(0 0
+ 35ns 0.00054
+ 50ns 0.00679
+ 65ns 0.0022
+ 80ns 0.000132
+ 95ns 0.00032
+ 110ns 0.0018
+ 125ns 0.00132
+ 140ns 0.008484
+ 155ns 0
+ 170ns 0.00372
+ 185ns 4.7e-05
+ 200ns 0
+ )
I920 0 N920_0 PWL(0 0
+ 23ns 0.00051
+ 38ns 0.00259
+ 53ns 0.00296
+ 68ns 0.000876
+ 83ns 8e-05
+ 98ns 0.00996
+ 113ns 0.00297
+ 128ns 0.008787
+ 143ns 0.002542
+ 158ns 0.00308
+ 173ns 2.8e-05
+ 188ns 0
+ )
I930 0 N930_0 PWL(0 0
+ 26ns 0.0009
+ 41ns 0.00616
+ 56ns 0.00012
+ 71ns 0.00012
+ 86ns 0.0064
+ 101ns 0.00264
+ 116ns 0.001947
+ 131ns 0.003636
+ 146ns 0.00527
+ 161ns 0.00256
+ 176ns 3e-06
+ 191ns 0
+ )
I940 0 N940_0 PWL(0 0
+ 15ns 0.00165
+ 30ns 0.0049
+ 45ns 0.00188
+ 60ns 0.000984
+ 75ns 0.00464
+ 90ns 0.00768
+ 105ns 0.002376
+ 120ns 0.008585
+ 135ns 0.002294
+ 150ns 0.00292
+ 165ns 6.8e-05
+ 180ns 0
+ )
I950 0 N950_0 PWL(0 0
+ 16ns 0.00183
+ 31ns 0.00063
+ 46ns 0.00356
+ 61ns 0.000684
+ 76ns 0.0008
+ 91ns 0.00228
+ 106ns 0.001518
+ 121ns 0.006666
+ 136ns 0.005084
+ 151ns 0.00312
+ 166ns 8.8e-05
+ 181ns 0
+ )
I960 0 N960_0 PWL(0 0
+ 21ns 0.00075
+ 36ns 0.00399
+ 51ns 0.00276
+ 66ns 3.6e-05
+ 81ns 0.00456
+ 96ns 0.00288
+ 111ns 0.000825
+ 126ns 0.000505
+ 141ns 0.000434
+ 156ns 0.00336
+ 171ns 6.9e-05
+ 186ns 0
+ )
I970 0 N970_0 PWL(0 0
+ 24ns 0.00177
+ 39ns 0.00028
+ 54ns 0.00356
+ 69ns 0.00108
+ 84ns 0.0052
+ 99ns 0.00612
+ 114ns 0.001683
+ 129ns 0.000707
+ 144ns 0.000496
+ 159ns 0.00248
+ 174ns 7.8e-05
+ 189ns 0
+ )
I980 0 N980_0 PWL(0 0
+ 43ns 0.0018
+ 58ns 0.00595
+ 73ns 0.00272
+ 88ns 0.000648
+ 103ns 0.00408
+ 118ns 0.0054
+ 133ns 0.000363
+ 148ns 0.002121
+ 163ns 0
+ 178ns 0.00276
+ 193ns 4.5e-05
+ 208ns 0
+ )
I990 0 N990_0 PWL(0 0
+ 41ns 0.00012
+ 56ns 0.00434
+ 71ns 0.0038
+ 86ns 0.00042
+ 101ns 0.00248
+ 116ns 0.00072
+ 131ns 0.00132
+ 146ns 0.00202
+ 161ns 0.003038
+ 176ns 0.00228
+ 191ns 2.3e-05
+ 206ns 0
+ )

* voltage sources
VA N0_0 0 0
VB N99_0 0 0
VC N900_0 0 0
VD N999_0 0 0

.tran 1ns 200ns

.end
